v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {Dummy} -1770 730 0 0 0.7 0.7 {}
T {Dummy} 1450 720 0 0 0.7 0.7 {}
T {Dummy} -610 720 0 0 0.7 0.7 {}
T {Dummy} 290 740 0 0 0.7 0.7 {}
T {C-} -320 780 0 0 0.7 0.7 {}
T {C+} 110 780 0 0 0.7 0.7 {}
T {C-'} -1890 770 0 0 0.7 0.7 {}
T {C+'} 1680 800 0 0 0.7 0.7 {}
T {D/A} 2020 320 0 0 1 1 {}
T {ENAD = 1: A/D
ENAD = 0: D/A} 2010 130 0 0 0.7 0.7 {}
N -240 -740 100 -740 {
lab=VDD}
N -210 -710 -170 -710 {
lab=#net1}
N -190 -710 -190 -680 {
lab=#net1}
N -190 -680 -140 -680 {
lab=#net1}
N 30 -710 70 -710 {
lab=#net2}
N 50 -710 50 -680 {
lab=#net2}
N 0 -680 50 -680 {
lab=#net2}
N -140 -680 -140 -660 {
lab=#net1}
N 0 -600 0 -580 {
lab=#net1}
N 0 -680 0 -660 {
lab=#net2}
N -140 -600 -140 -580 {
lab=#net2}
N -140 -600 0 -660 {
lab=#net2}
N -140 -660 0 -600 {
lab=#net1}
N 100 -680 100 -660 {
lab=#net3}
N -240 -680 -240 -660 {
lab=#net4}
N -140 -520 0 -520 {
lab=#net5}
N -70 -520 -70 -500 {
lab=#net5}
N -220 -470 20 -470 {
lab=Vb}
N -190 -440 50 -440 {
lab=GND}
N -190 -680 -190 -500 {
lab=#net1}
N 50 -680 50 -490 {
lab=#net2}
N -240 -600 -240 -370 {
lab=AIn}
N -100 -370 -40 -370 {
lab=ENADb}
N 100 -600 100 -370 {
lab=CompOut}
N -210 -340 70 -340 {
lab=#net6}
N -210 -210 -110 -210 {
lab=#net7}
N -50 -210 70 -210 {
lab=#net8}
N -240 -310 -240 -240 {
lab=#net9}
N 100 -310 100 -240 {
lab=#net7}
N -240 -310 -10 -270 {
lab=#net9}
N -130 -270 100 -310 {
lab=#net7}
N -130 -270 -130 -210 {
lab=#net7}
N -130 -210 -130 -100 {
lab=#net7}
N -130 -100 -100 -100 {
lab=#net7}
N -40 -100 -10 -100 {
lab=#net8}
N -10 -210 -10 -100 {
lab=#net8}
N -240 -180 -240 -40 {
lab=GND}
N -240 -40 100 -40 {
lab=GND}
N 100 -180 100 -40 {
lab=GND}
N -1940 610 -1800 610 {
lab=#net10}
N -1940 550 -1800 550 {
lab=Vref-}
N -1870 610 -1870 650 {
lab=#net10}
N -1870 630 -1700 630 {
lab=#net10}
N -1770 650 -1630 650 {
lab=#net10}
N -1700 630 -1700 650 {
lab=#net10}
N -1530 650 -1390 650 {
lab=#net10}
N -1700 630 -1460 630 {
lab=#net10}
N -1460 630 -1460 650 {
lab=#net10}
N -1530 710 -1390 710 {
lab=#net11}
N -1290 440 -950 440 {
lab=VDD}
N -1260 470 -1220 470 {
lab=#net12}
N -1240 470 -1240 500 {
lab=#net12}
N -1240 500 -1190 500 {
lab=#net12}
N -1020 470 -980 470 {
lab=#net13}
N -1000 470 -1000 500 {
lab=#net13}
N -1050 500 -1000 500 {
lab=#net13}
N -1190 500 -1190 520 {
lab=#net12}
N -1050 580 -1050 600 {
lab=#net12}
N -1050 500 -1050 520 {
lab=#net13}
N -1190 580 -1190 600 {
lab=#net13}
N -1190 580 -1050 520 {
lab=#net13}
N -1190 520 -1050 580 {
lab=#net12}
N -950 500 -950 520 {
lab=#net14}
N -1290 500 -1290 520 {
lab=#net15}
N -1190 660 -1050 660 {
lab=#net16}
N -1120 660 -1120 680 {
lab=#net16}
N -1460 630 -1220 630 {
lab=#net10}
N -1290 580 -1290 790 {
lab=#net11}
N -950 580 -950 790 {
lab=#net17}
N -1260 820 -980 820 {
lab=#net18}
N -1290 850 -1290 890 {
lab=#net19}
N -1290 860 -1220 860 {
lab=#net19}
N -950 850 -950 890 {
lab=#net20}
N -1020 860 -950 860 {
lab=#net20}
N -1050 790 -1050 990 {
lab=D}
N -1190 790 -1190 990 {
lab=Db}
N -1290 950 -950 950 {
lab=GND}
N -1260 920 -980 920 {
lab=#net21}
N -610 650 -470 650 {
lab=#net22}
N -540 630 -540 650 {
lab=#net22}
N -850 650 -710 650 {
lab=#net22}
N -780 630 -540 630 {
lab=#net22}
N -780 630 -780 650 {
lab=#net22}
N -850 710 -710 710 {
lab=#net17}
N -1020 630 -780 630 {
lab=#net22}
N -1120 740 -1120 950 {
lab=GND}
N -370 530 -230 530 {
lab=Vref-}
N -300 510 -300 530 {
lab=Vref-}
N -370 590 -230 590 {
lab=#net22}
N -300 590 -300 630 {
lab=#net22}
N -540 630 -300 630 {
lab=#net22}
N -300 630 -300 650 {
lab=#net22}
N -120 560 -120 700 {
lab=#net22}
N -140 630 -120 630 {
lab=#net22}
N -60 560 -60 700 {
lab=#net23}
N -300 630 -140 630 {
lab=#net22}
N -1940 610 -1800 610 {
lab=#net10}
N -1940 550 -1800 550 {
lab=Vref-}
N -1870 610 -1870 650 {
lab=#net10}
N -1870 630 -1700 630 {
lab=#net10}
N -1770 650 -1630 650 {
lab=#net10}
N -1700 630 -1700 650 {
lab=#net10}
N -1530 650 -1390 650 {
lab=#net10}
N -1700 630 -1460 630 {
lab=#net10}
N -1460 630 -1460 650 {
lab=#net10}
N -1530 710 -1390 710 {
lab=#net11}
N -1290 440 -950 440 {
lab=VDD}
N -1260 470 -1220 470 {
lab=#net12}
N -1240 470 -1240 500 {
lab=#net12}
N -1240 500 -1190 500 {
lab=#net12}
N -1020 470 -980 470 {
lab=#net13}
N -1000 470 -1000 500 {
lab=#net13}
N -1050 500 -1000 500 {
lab=#net13}
N -1190 500 -1190 520 {
lab=#net12}
N -1050 580 -1050 600 {
lab=#net12}
N -1050 500 -1050 520 {
lab=#net13}
N -1190 580 -1190 600 {
lab=#net13}
N -1190 580 -1050 520 {
lab=#net13}
N -1190 520 -1050 580 {
lab=#net12}
N -950 500 -950 520 {
lab=#net14}
N -1290 500 -1290 520 {
lab=#net15}
N -1190 660 -1050 660 {
lab=#net16}
N -1120 660 -1120 680 {
lab=#net16}
N -1460 630 -1220 630 {
lab=#net10}
N -1290 580 -1290 790 {
lab=#net11}
N -950 580 -950 790 {
lab=#net17}
N -1260 820 -980 820 {
lab=#net18}
N -1290 850 -1290 890 {
lab=#net19}
N -1290 860 -1220 860 {
lab=#net19}
N -950 850 -950 890 {
lab=#net20}
N -1020 860 -950 860 {
lab=#net20}
N -1050 790 -1050 990 {
lab=D}
N -1190 790 -1190 990 {
lab=Db}
N -1290 950 -950 950 {
lab=GND}
N -1260 920 -980 920 {
lab=#net21}
N -610 650 -470 650 {
lab=#net22}
N -540 630 -540 650 {
lab=#net22}
N -850 650 -710 650 {
lab=#net22}
N -780 630 -540 630 {
lab=#net22}
N -780 630 -780 650 {
lab=#net22}
N -850 710 -710 710 {
lab=#net17}
N -1020 630 -780 630 {
lab=#net22}
N -1120 740 -1120 950 {
lab=GND}
N -370 530 -230 530 {
lab=Vref-}
N -300 510 -300 530 {
lab=Vref-}
N -370 590 -230 590 {
lab=#net22}
N -300 590 -300 630 {
lab=#net22}
N -540 630 -300 630 {
lab=#net22}
N -300 630 -300 650 {
lab=#net22}
N 1620 610 1760 610 {
lab=#net24}
N 1690 610 1690 650 {
lab=#net24}
N 1520 630 1690 630 {
lab=#net24}
N 1450 650 1590 650 {
lab=#net24}
N 1520 630 1520 650 {
lab=#net24}
N 1210 650 1350 650 {
lab=#net24}
N 1280 630 1520 630 {
lab=#net24}
N 1280 630 1280 650 {
lab=#net24}
N 1210 710 1350 710 {
lab=#net25}
N 770 440 1110 440 {
lab=VDD}
N 1040 470 1080 470 {
lab=#net26}
N 1060 470 1060 500 {
lab=#net26}
N 1010 500 1060 500 {
lab=#net26}
N 800 470 840 470 {
lab=#net27}
N 820 470 820 500 {
lab=#net27}
N 820 500 870 500 {
lab=#net27}
N 1010 500 1010 520 {
lab=#net26}
N 870 580 870 600 {
lab=#net26}
N 870 500 870 520 {
lab=#net27}
N 1010 580 1010 600 {
lab=#net27}
N 870 520 1010 580 {
lab=#net27}
N 870 580 1010 520 {
lab=#net26}
N 770 500 770 520 {
lab=#net28}
N 1110 500 1110 520 {
lab=#net29}
N 870 660 1010 660 {
lab=#net30}
N 940 660 940 680 {
lab=#net30}
N 1040 630 1280 630 {
lab=#net24}
N 1110 580 1110 790 {
lab=#net25}
N 770 580 770 790 {
lab=#net31}
N 800 820 1080 820 {
lab=#net32}
N 1110 850 1110 890 {
lab=#net33}
N 1040 860 1110 860 {
lab=#net33}
N 770 850 770 890 {
lab=#net34}
N 770 860 840 860 {
lab=#net34}
N 870 790 870 990 {
lab=Db}
N 1010 790 1010 990 {
lab=D}
N 770 950 1110 950 {
lab=GND}
N 800 920 1080 920 {
lab=#net35}
N 290 650 430 650 {
lab=#net23}
N 360 630 360 650 {
lab=#net23}
N 530 650 670 650 {
lab=#net23}
N 360 630 600 630 {
lab=#net23}
N 600 630 600 650 {
lab=#net23}
N 530 710 670 710 {
lab=#net31}
N 600 630 840 630 {
lab=#net23}
N 940 740 940 950 {
lab=GND}
N 120 510 120 530 {
lab=Vref+}
N 50 590 190 590 {
lab=#net23}
N 120 590 120 630 {
lab=#net23}
N 120 630 360 630 {
lab=#net23}
N 120 630 120 650 {
lab=#net23}
N -60 630 120 630 {
lab=#net23}
N -310 -630 -270 -630 {
lab=Vcp}
N 130 -630 160 -630 {
lab=Vcp}
N -300 -470 -220 -470 {
lab=Vb}
N -390 -550 -170 -550 {
lab=AIn}
N -40 -250 -40 -240 {
lab=ENAD}
N -440 -250 -40 -250 {
lab=ENAD}
N -80 -180 -80 -170 {
lab=ENADb}
N -440 -170 -80 -170 {
lab=ENADb}
N -430 -70 -70 -70 {
lab=RST}
N -440 -70 -430 -70 {
lab=RST}
N -450 -550 -390 -550 {
lab=AIn}
N -1870 520 -1870 550 {
lab=Vref-}
N -1970 490 -1970 580 {
lab=PREb}
N -1770 490 -1770 580 {
lab=PRE}
N 1590 520 1590 580 {
lab=PRE}
N 1790 520 1790 580 {
lab=PREb}
N -1700 650 -1700 710 {
lab=#net10}
N -1700 710 -1630 710 {
lab=#net10}
N -1770 710 -1700 710 {
lab=#net10}
N -1800 640 -1800 680 {
lab=STO+_RCL-}
N -1800 640 -1730 640 {
lab=STO+_RCL-}
N -1730 490 -1730 640 {
lab=STO+_RCL-}
N -1600 490 -1600 680 {
lab=STO+b_RCL-b}
N -1560 490 -1560 680 {
lab=STO-_RCL+}
N -1360 580 -1360 680 {
lab=STO-b_RCL+b}
N -1450 580 -1360 580 {
lab=STO-b_RCL+b}
N -1450 490 -1450 580 {
lab=STO-b_RCL+b}
N -1460 710 -1460 720 {
lab=#net11}
N -1220 720 -1220 760 {
lab=#net11}
N -1590 40 -1590 90 {
lab=PRE}
N -1440 40 -1440 90 {
lab=PREb}
N 1520 650 1520 710 {
lab=#net24}
N 1450 710 1520 710 {
lab=#net24}
N 1520 710 1590 710 {
lab=#net24}
N 1180 610 1180 680 {
lab=STO+b_RCL-b}
N 1180 610 1210 610 {
lab=STO+b_RCL-b}
N 1380 560 1380 680 {
lab=STO+_RCL-}
N 1210 610 1240 610 {
lab=STO+b_RCL-b}
N 1240 560 1240 610 {
lab=STO+b_RCL-b}
N 1420 560 1420 680 {
lab=STO-b_RCL+b}
N 1620 620 1620 680 {
lab=STO-_RCL+}
N 1540 620 1620 620 {
lab=STO-_RCL+}
N 1540 560 1540 620 {
lab=STO-_RCL+}
N 1290 710 1290 740 {
lab=#net25}
N 1040 740 1040 760 {
lab=#net25}
N -90 410 -90 530 {
lab=SH}
N -90 730 -90 820 {
lab=SHb}
N -400 480 -400 560 {
lab=PREb}
N -200 480 -200 560 {
lab=PRE}
N 210 -540 210 -210 {
lab=#net36}
N 210 -550 210 -540 {
lab=#net36}
N 30 -550 210 -550 {
lab=#net36}
N -150 280 -140 280 {
lab=#net22}
N -140 280 -140 490 {
lab=#net22}
N -140 490 -140 590 {
lab=#net22}
N -300 630 -140 590 {
lab=#net22}
N -150 190 -30 190 {
lab=Vf}
N -30 280 -30 590 {
lab=#net23}
N -30 590 120 630 {
lab=#net23}
N 50 530 190 530 {
lab=Vref+}
N 120 510 120 530 {
lab=Vref+}
N 50 530 190 530 {
lab=Vref+}
N 120 510 120 530 {
lab=Vref+}
N 20 480 20 560 {
lab=PRE}
N 220 480 220 560 {
lab=PREb}
N -0 220 0 250 {
lab=#net36}
N -180 160 0 160 {
lab=VDD}
N -180 220 -180 250 {
lab=#net37}
N -180 310 0 310 {
lab=GND}
N 210 -210 210 230 {
lab=#net36}
N 0 230 210 230 {
lab=#net36}
N -540 650 -540 710 {
lab=#net22}
N -610 710 -540 710 {
lab=#net22}
N -540 710 -470 710 {
lab=#net22}
N -580 530 -580 610 {
lab=STO-b_RCL+b}
N -640 610 -580 610 {
lab=STO-b_RCL+b}
N -640 610 -640 680 {
lab=STO-b_RCL+b}
N -510 530 -510 610 {
lab=STO-_RCL+}
N -510 610 -440 610 {
lab=STO-_RCL+}
N -440 610 -440 680 {
lab=STO-_RCL+}
N -820 530 -820 600 {
lab=STO+b_RCL-b}
N -880 600 -820 600 {
lab=STO+b_RCL-b}
N -880 600 -880 680 {
lab=STO+b_RCL-b}
N -1020 730 -1020 760 {
lab=#net17}
N -780 710 -780 730 {
lab=#net17}
N 360 650 360 700 {
lab=#net23}
N 360 700 360 710 {
lab=#net23}
N 290 710 360 710 {
lab=#net23}
N 360 710 430 710 {
lab=#net23}
N 290 610 320 610 {
lab=STO+_RCL-}
N 320 560 320 610 {
lab=STO+_RCL-}
N 460 560 460 680 {
lab=STO+b_RCL-b}
N 260 610 290 610 {
lab=STO+_RCL-}
N 260 610 260 680 {
lab=STO+_RCL-}
N 500 560 500 680 {
lab=STO-_RCL+}
N 670 560 670 640 {
lab=STO-b_RCL+b}
N 670 640 700 640 {
lab=STO-b_RCL+b}
N 700 640 700 680 {
lab=STO-b_RCL+b}
N 600 710 600 740 {
lab=#net31}
N 840 740 840 760 {
lab=#net31}
N -420 190 -150 190 {
lab=Vf}
N 1620 550 1760 550 {
lab=Vref+}
N 1690 530 1690 550 {
lab=Vref+}
N -730 530 -730 600 {
lab=STO+_RCL-}
N -730 600 -680 600 {
lab=STO+_RCL-}
N -680 600 -680 680 {
lab=STO+_RCL-}
N -920 330 -920 550 {
lab=Vcp}
N -1320 330 -1320 550 {
lab=Vcp}
N -1320 330 -920 330 {
lab=Vcp}
N 700 550 740 550 {
lab=Vcp}
N 700 340 700 550 {
lab=Vcp}
N 700 340 1160 340 {
lab=Vcp}
N 1160 340 1160 550 {
lab=Vcp}
N 1140 550 1160 550 {
lab=Vcp}
N -440 -380 -80 -380 {
lab=ENADb}
N -80 -380 -80 -370 {
lab=ENADb}
N -630 -410 -240 -410 {
lab=AIn}
N -570 -410 -570 -260 {
lab=AIn}
N -780 -260 -570 -260 {
lab=AIn}
N -780 -260 -780 -180 {
lab=AIn}
N -840 -260 -840 -180 {
lab=AOut}
N -880 -260 -840 -260 {
lab=AOut}
N -1240 1460 -1100 1460 {
lab=#net38}
N -1100 1460 -870 1460 {
lab=#net38}
N -960 1420 -960 1470 {
lab=STO-b_RCL+b}
N -960 1530 -960 1550 {
lab=#net39}
N -1170 1460 -1170 1470 {
lab=#net38}
N -1170 1530 -1170 1550 {
lab=#net40}
N -1200 1500 -990 1500 {
lab=SEN}
N -1200 1580 -990 1580 {
lab=D}
N -1270 1430 -1270 1580 {
lab=D}
N -1270 1580 -1200 1580 {
lab=D}
N -1270 1580 -1270 1610 {
lab=D}
N -840 1490 -840 1610 {
lab=STO-_RCL+}
N -960 1390 -960 1420 {
lab=STO-b_RCL+b}
N -960 1400 -710 1400 {
lab=STO-b_RCL+b}
N -840 1580 -710 1580 {
lab=STO-_RCL+}
N 600 1460 740 1460 {
lab=#net41}
N 740 1460 970 1460 {
lab=#net41}
N 880 1420 880 1470 {
lab=STO+b_RCL-b}
N 880 1530 880 1550 {
lab=#net42}
N 670 1460 670 1470 {
lab=#net41}
N 670 1530 670 1550 {
lab=#net43}
N 640 1500 850 1500 {
lab=SEN}
N 640 1580 850 1580 {
lab=D}
N 570 1430 570 1580 {
lab=D}
N 570 1580 640 1580 {
lab=D}
N 570 1580 570 1610 {
lab=D}
N 1000 1490 1000 1610 {
lab=STO+_RCL-}
N 880 1390 880 1420 {
lab=STO+b_RCL-b}
N 880 1400 1140 1400 {
lab=STO+b_RCL-b}
N 1000 1580 1140 1580 {
lab=STO+_RCL-}
N -270 1370 -270 1380 {
lab=#net44}
N 50 1370 50 1380 {
lab=#net45}
N -270 1440 -270 1620 {
lab=D}
N 50 1440 50 1620 {
lab=Db}
N 50 1680 50 1690 {
lab=#net46}
N -270 1680 -270 1690 {
lab=#net47}
N -240 1410 20 1410 {
lab=ENADb}
N -240 1650 20 1650 {
lab=ENAD}
N -100 1610 -100 1650 {
lab=ENAD}
N -100 1410 -100 1460 {
lab=ENADb}
N -310 1720 -300 1720 {
lab=CompOutb}
N -310 1340 -310 1720 {
lab=CompOutb}
N -310 1340 -300 1340 {
lab=CompOutb}
N 80 1340 90 1340 {
lab=CompOut}
N 90 1340 90 1720 {
lab=CompOut}
N 80 1720 90 1720 {
lab=CompOut}
N -270 1470 -250 1470 {
lab=D}
N -330 1470 -310 1470 {
lab=CompOutb}
N 30 1470 50 1470 {
lab=Db}
N 90 1470 110 1470 {
lab=CompOut}
N -100 1650 -100 1670 {
lab=ENAD}
N -100 1390 -100 1410 {
lab=ENADb}
N -10 -400 100 -400 {
lab=CompOut}
N 100 -400 260 -400 {
lab=CompOut}
N -430 -550 -430 -290 {
lab=AIn}
N -570 -290 -430 -290 {
lab=AIn}
N -1460 720 -1290 720 {
lab=#net11}
N -1290 720 -1220 720 {
lab=#net11}
N -1020 730 -950 730 {
lab=#net17}
N -950 730 -780 730 {
lab=#net17}
N 600 740 770 740 {
lab=#net31}
N 770 740 840 740 {
lab=#net31}
N 1040 740 1110 740 {
lab=#net25}
N 1110 740 1290 740 {
lab=#net25}
C {madvlsi/pmos3.sym} -240 -710 0 1 {name=M1
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -140 -710 0 0 {name=M2
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 0 -710 0 1 {name=M3
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 100 -710 0 0 {name=M4
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -240 -630 0 0 {name=M5
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 100 -630 0 1 {name=M6
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -70 -470 0 0 {name=M7
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 0 -550 0 1 {name=M8
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -140 -550 0 0 {name=M9
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -190 -470 0 0 {name=M10
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 50 -470 0 0 {name=M11
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -240 -340 0 1 {name=M12
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -130 -370 0 1 {name=M13
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -10 -370 0 0 {name=M14
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 100 -340 0 0 {name=M15
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -10 -240 0 0 {name=M16
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -240 -210 0 1 {name=M17
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 100 -210 0 0 {name=M18
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -80 -210 3 0 {name=M19
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -70 -100 3 0 {name=M20
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} -130 -70 0 0 {name=C1
value=0.1p
m=1}
C {madvlsi/capacitor.sym} -10 -70 0 0 {name=C2
value=0.1p
m=1}
C {madvlsi/pmos3.sym} -90 700 3 0 {name=M50
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -90 560 1 0 {name=M51
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -1940 580 0 0 {name=M52
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1800 580 2 0 {name=M53
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} -1870 680 0 0 {name=C5
value=1p
m=1}
C {madvlsi/pmos3.sym} -1630 680 0 1 {name=M54
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1770 680 2 1 {name=M55
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -1390 680 0 1 {name=M56
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1530 680 2 1 {name=M57
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -1290 470 0 1 {name=M58
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -1190 470 0 0 {name=M59
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -1050 470 0 1 {name=M60
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -950 470 0 0 {name=M61
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -1290 550 0 0 {name=M62
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -950 550 0 1 {name=M63
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1050 630 0 1 {name=M64
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1190 630 0 0 {name=M65
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1120 710 0 0 {name=M66
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1220 790 0 1 {name=M67
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1290 820 0 1 {name=M68
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1020 790 0 0 {name=M69
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -950 820 0 0 {name=M70
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1220 890 0 1 {name=M71
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1290 920 0 1 {name=M72
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1020 890 0 0 {name=M73
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -950 920 0 0 {name=M74
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -610 680 0 0 {name=M75
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -470 680 2 0 {name=M76
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -850 680 0 0 {name=M77
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -710 680 2 0 {name=M78
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -370 560 0 0 {name=M79
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -230 560 2 0 {name=M80
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} -300 680 0 0 {name=C6
value=1p
m=1}
C {madvlsi/pmos3.sym} 1760 580 0 1 {name=M81
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1620 580 2 1 {name=M82
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} 1690 680 0 1 {name=C7
value=1p
m=1}
C {madvlsi/pmos3.sym} 1450 680 0 0 {name=M83
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1590 680 2 0 {name=M84
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1210 680 0 0 {name=M85
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1350 680 2 0 {name=M86
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1110 470 0 0 {name=M87
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1010 470 0 1 {name=M88
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 870 470 0 0 {name=M89
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 770 470 0 1 {name=M90
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1110 550 0 1 {name=M91
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 770 550 0 0 {name=M92
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 870 630 0 0 {name=M93
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1010 630 0 1 {name=M94
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 940 710 0 1 {name=M95
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1040 790 0 0 {name=M96
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1110 820 0 0 {name=M97
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 840 790 0 1 {name=M98
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 770 820 0 1 {name=M99
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1040 890 0 0 {name=M100
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1110 920 0 0 {name=M101
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 840 890 0 1 {name=M102
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 770 920 0 1 {name=M103
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 430 680 0 1 {name=M104
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 290 680 2 1 {name=M105
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 670 680 0 1 {name=M106
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 530 680 2 1 {name=M107
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 190 560 0 1 {name=M108
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 50 560 2 1 {name=M109
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/capacitor.sym} 120 680 0 1 {name=C8
value=1p
m=1}
C {devices/lab_pin.sym} -1120 440 1 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 940 440 1 0 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -70 -740 1 0 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -130 -400 1 0 {name=p4 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -70 -440 3 0 {name=p5 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -70 -40 3 0 {name=p6 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -1870 710 3 0 {name=p7 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -1120 950 3 0 {name=p8 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -300 710 3 0 {name=p9 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 120 710 3 0 {name=p10 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 940 950 3 0 {name=p11 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1690 710 3 0 {name=p12 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -310 -630 0 0 {name=p13 sig_type=std_logic lab=Vcp}
C {devices/lab_pin.sym} 160 -630 2 0 {name=p14 sig_type=std_logic lab=Vcp}
C {devices/lab_pin.sym} -300 -470 0 0 {name=p15 sig_type=std_logic lab=Vb}
C {devices/lab_pin.sym} -450 -550 0 0 {name=p16 sig_type=std_logic lab=AIn}
C {devices/lab_pin.sym} 260 -400 2 0 {name=p17 sig_type=std_logic lab=CompOut}
C {devices/lab_pin.sym} -440 -250 0 0 {name=p18 sig_type=std_logic lab=ENAD}
C {devices/lab_pin.sym} -440 -170 0 0 {name=p19 sig_type=std_logic lab=ENADb}
C {devices/lab_pin.sym} -440 -70 0 0 {name=p20 sig_type=std_logic lab=RST}
C {devices/lab_pin.sym} -1870 520 0 0 {name=p21 sig_type=std_logic lab=Vref-}
C {devices/lab_pin.sym} -1970 490 0 0 {name=p22 sig_type=std_logic lab=PREb}
C {devices/lab_pin.sym} -1770 490 0 0 {name=p23 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 1690 530 0 0 {name=p26 sig_type=std_logic lab=Vref+}
C {devices/lab_pin.sym} 1790 520 2 0 {name=p27 sig_type=std_logic lab=PREb}
C {devices/lab_pin.sym} 1590 520 2 0 {name=p28 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} -1190 990 3 0 {name=p31 sig_type=std_logic lab=Db}
C {devices/lab_pin.sym} -1050 990 3 0 {name=p32 sig_type=std_logic lab=D}
C {devices/lab_pin.sym} 870 990 3 0 {name=p35 sig_type=std_logic lab=Db}
C {devices/lab_pin.sym} 1010 990 3 0 {name=p36 sig_type=std_logic lab=D}
C {devices/lab_pin.sym} 950 1170 3 0 {name=p37 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 950 1020 0 0 {name=p38 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -1510 10 1 0 {name=p41 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -1510 160 3 0 {name=p42 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -1440 40 2 0 {name=p49 sig_type=std_logic lab=PREb}
C {devices/lab_pin.sym} -1590 40 0 0 {name=p50 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} -90 410 0 0 {name=p57 sig_type=std_logic lab=SH}
C {devices/lab_pin.sym} -90 820 0 0 {name=p58 sig_type=std_logic lab=SHb}
C {devices/lab_pin.sym} -300 510 0 0 {name=p61 sig_type=std_logic lab=Vref-}
C {devices/lab_pin.sym} -400 480 0 0 {name=p62 sig_type=std_logic lab=PREb}
C {devices/lab_pin.sym} -200 480 0 0 {name=p63 sig_type=std_logic lab=PRE}
C {madvlsi/pmos3.sym} -180 190 2 0 {name=M21
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -180 280 2 0 {name=M22
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 0 190 0 0 {name=M23
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 0 280 0 0 {name=M24
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 120 510 0 0 {name=p64 sig_type=std_logic lab=Vref+}
C {devices/lab_pin.sym} 220 480 0 0 {name=p65 sig_type=std_logic lab=PREb}
C {devices/lab_pin.sym} 20 480 0 0 {name=p66 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} -90 310 3 0 {name=p67 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -80 160 1 0 {name=p68 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -420 190 0 0 {name=p77 sig_type=std_logic lab=Vf}
C {devices/lab_pin.sym} -1120 330 1 0 {name=p78 sig_type=std_logic lab=Vcp}
C {devices/lab_pin.sym} 930 340 1 0 {name=p79 sig_type=std_logic lab=Vcp}
C {devices/lab_pin.sym} -100 1040 3 0 {name=p80 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -100 890 0 0 {name=p81 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -30 970 2 0 {name=p82 sig_type=std_logic lab=SHb}
C {devices/lab_pin.sym} -180 970 0 0 {name=p83 sig_type=std_logic lab=SH}
C {devices/lab_pin.sym} -440 -380 0 0 {name=p84 sig_type=std_logic lab=ENADb}
C {devices/lab_pin.sym} -1150 710 0 0 {name=p85 sig_type=std_logic lab=Vb}
C {devices/lab_pin.sym} 970 710 2 0 {name=p86 sig_type=std_logic lab=Vb}
C {devices/lab_pin.sym} -640 -410 0 0 {name=p87 sig_type=std_logic lab=CompOutb}
C {madvlsi/nmos3.sym} -810 -260 1 0 {name=M25
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -810 -180 3 0 {name=M26
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -880 -260 0 0 {name=p88 sig_type=std_logic lab=AOut}
C {devices/lab_pin.sym} -810 -150 0 0 {name=p89 sig_type=std_logic lab=ENADb}
C {devices/lab_pin.sym} -810 -290 0 0 {name=p90 sig_type=std_logic lab=ENAD}
C {devices/lab_pin.sym} 880 1100 0 0 {name=p93 sig_type=std_logic lab=Db}
C {devices/lab_pin.sym} 1030 1100 2 0 {name=p94 sig_type=std_logic lab=D}
C {./inverter.sym} -1480 90 0 0 {name=x10}
C {./inverter.sym} 920 1100 0 1 {name=x4}
C {./inverter.sym} -70 970 0 0 {name=x8}
C {devices/code_shown.sym} 2000 1580 0 0 {name=SPICE only_toplevel=false value=".param W = 12
.param L = .5
.tran 10n 20u
.save v(sh) v(db) v(pre) v(preb) v(shb) v(rst) V(sen) V(d) v(CompOut) v(AOut) i(VCompOut)"
}
C {madvlsi/tt_models.sym} 1980 1420 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {madvlsi/pmos3.sym} -960 1360 0 0 {name=M27
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -1100 1430 0 1 {name=M28
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -1240 1430 0 0 {name=M29
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1170 1500 0 0 {name=M30
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1170 1580 0 0 {name=M31
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -960 1500 0 0 {name=M32
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -960 1580 0 0 {name=M33
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -840 1460 0 0 {name=M34
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -840 1640 0 0 {name=M35
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1200 1500 0 0 {name=p108 sig_type=std_logic lab=SEN}
C {devices/lab_pin.sym} -1070 1430 2 0 {name=p109 sig_type=std_logic lab=SEN}
C {devices/lab_pin.sym} -1270 1610 3 0 {name=p110 sig_type=std_logic lab=D}
C {devices/lab_pin.sym} -990 1360 0 0 {name=p111 sig_type=std_logic lab=SRp}
C {devices/lab_pin.sym} -1240 1400 1 0 {name=p112 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -1100 1400 1 0 {name=p113 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -960 1330 1 0 {name=p114 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -840 1430 1 0 {name=p115 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -1170 1610 3 0 {name=p116 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -960 1610 3 0 {name=p117 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -840 1670 3 0 {name=p118 sig_type=std_logic lab=GND}
C {madvlsi/capacitor.sym} -750 1430 0 0 {name=C3
value=0.1p
m=1}
C {madvlsi/capacitor.sym} -750 1610 0 0 {name=C4
value=0.1p
m=1}
C {devices/lab_pin.sym} -750 1460 3 0 {name=p119 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -750 1640 3 0 {name=p120 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -870 1640 0 0 {name=p121 sig_type=std_logic lab=SRn}
C {devices/lab_pin.sym} -710 1400 2 0 {name=p123 sig_type=std_logic lab=STO-b_RCL+b}
C {madvlsi/pmos3.sym} 880 1360 0 0 {name=M36
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 740 1430 0 1 {name=M37
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 600 1430 0 0 {name=M38
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 670 1500 0 0 {name=M39
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 670 1580 0 0 {name=M40
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 880 1500 0 0 {name=M41
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 880 1580 0 0 {name=M42
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1000 1460 0 0 {name=M43
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1000 1640 0 0 {name=M44
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 640 1500 0 0 {name=p124 sig_type=std_logic lab=SEN}
C {devices/lab_pin.sym} 770 1430 2 0 {name=p125 sig_type=std_logic lab=SEN}
C {devices/lab_pin.sym} 570 1610 3 0 {name=p126 sig_type=std_logic lab=Db}
C {devices/lab_pin.sym} 850 1360 0 0 {name=p127 sig_type=std_logic lab=SRp}
C {devices/lab_pin.sym} 600 1400 1 0 {name=p128 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 740 1400 1 0 {name=p129 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 880 1330 1 0 {name=p130 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1000 1430 1 0 {name=p131 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 670 1610 3 0 {name=p132 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 880 1610 3 0 {name=p133 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1000 1670 3 0 {name=p134 sig_type=std_logic lab=GND}
C {madvlsi/capacitor.sym} 1090 1430 0 0 {name=C9
value=0.1p
m=1}
C {madvlsi/capacitor.sym} 1090 1610 0 0 {name=C10
value=0.1p
m=1}
C {devices/lab_pin.sym} 1090 1460 3 0 {name=p135 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1090 1640 3 0 {name=p136 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 970 1640 0 0 {name=p137 sig_type=std_logic lab=SRn}
C {devices/lab_pin.sym} 1140 1400 2 0 {name=p139 sig_type=std_logic lab=STO+b_RCL-b}
C {devices/lab_pin.sym} 1140 1580 2 0 {name=p141 sig_type=std_logic lab=STO+_RCL-}
C {devices/lab_pin.sym} -710 1580 2 0 {name=p143 sig_type=std_logic lab=STO-_RCL+}
C {madvlsi/pmos3.sym} -270 1340 0 0 {name=M45
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -270 1410 2 0 {name=M46
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 50 1340 0 1 {name=M47
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 50 1410 2 1 {name=M48
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {./inverter.sym} -100 1500 3 0 {name=x9}
C {madvlsi/nmos3.sym} -270 1650 2 0 {name=M49
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -270 1720 0 0 {name=M110
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 50 1650 2 1 {name=M111
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 50 1720 0 1 {name=M112
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -270 1310 1 0 {name=p144 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 50 1310 1 0 {name=p145 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -180 1530 0 0 {name=p146 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -270 1750 3 0 {name=p147 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 50 1750 3 0 {name=p148 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -30 1530 2 0 {name=p149 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -250 1470 2 0 {name=p150 sig_type=std_logic lab=D}
C {devices/lab_pin.sym} 30 1470 0 0 {name=p151 sig_type=std_logic lab=Db}
C {devices/lab_pin.sym} -330 1470 0 0 {name=p152 sig_type=std_logic lab=CompOutb}
C {devices/lab_pin.sym} 110 1470 2 0 {name=p153 sig_type=std_logic lab=CompOut}
C {madvlsi/vsource.sym} 2040 1080 0 0 {name=VDD
value=1.8}
C {madvlsi/vdd.sym} 2040 1050 0 0 {name=l1 lab=VDD}
C {madvlsi/gnd.sym} 2040 1110 0 0 {name=l2 lab=GND}
C {madvlsi/vdd.sym} 2040 1210 0 0 {name=l3 lab=VDD}
C {madvlsi/gnd.sym} 2100 1230 0 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} 2100 1230 1 0 {name=p95 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 2040 1210 3 0 {name=p96 sig_type=std_logic lab=VDD}
C {madvlsi/vsource.sym} 2120 1080 0 0 {name=Vf
value=1}
C {madvlsi/gnd.sym} 2120 1110 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 2120 1050 1 0 {name=p97 sig_type=std_logic lab=Vf}
C {madvlsi/vsource.sym} 2190 1080 0 0 {name=Vb
value=1}
C {madvlsi/gnd.sym} 2190 1110 0 0 {name=l6 lab=GND}
C {devices/lab_pin.sym} 2190 1050 1 0 {name=p98 sig_type=std_logic lab=Vb}
C {madvlsi/vsource.sym} 2260 1080 0 0 {name=Vcp
value=0.8}
C {madvlsi/gnd.sym} 2260 1110 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 2260 1050 1 0 {name=p99 sig_type=std_logic lab=Vcp}
C {madvlsi/vsource.sym} 2330 1080 0 0 {name=VSRn
value=1}
C {madvlsi/gnd.sym} 2330 1110 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 2330 1050 1 0 {name=p100 sig_type=std_logic lab=SRn}
C {madvlsi/vsource.sym} 2400 1080 0 0 {name=VSRp
value=1}
C {madvlsi/gnd.sym} 2400 1110 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 2400 1050 1 0 {name=p101 sig_type=std_logic lab=SRp}
C {madvlsi/vsource.sym} 2180 1260 0 0 {name=Vrefp
value=1.8}
C {madvlsi/gnd.sym} 2180 1290 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 2180 1230 1 0 {name=p102 sig_type=std_logic lab=Vref+}
C {madvlsi/vsource.sym} 2250 1260 0 0 {name=Vrefn
value=0}
C {madvlsi/gnd.sym} 2250 1290 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 2250 1230 1 0 {name=p103 sig_type=std_logic lab=Vref-}
C {madvlsi/vsource.sym} 2410 180 0 0 {name=VENAD
value=0}
C {madvlsi/gnd.sym} 2410 210 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} 2410 150 1 0 {name=p157 sig_type=std_logic lab=ENAD}
C {devices/lab_pin.sym} -100 1390 1 0 {name=p33 sig_type=std_logic lab=ENADb}
C {devices/lab_pin.sym} -100 1670 3 0 {name=p34 sig_type=std_logic lab=ENAD}
C {devices/lab_pin.sym} -580 530 1 0 {name=p91 sig_type=std_logic lab=STO-b_RCL+b}
C {devices/lab_pin.sym} -1450 490 1 0 {name=p48 sig_type=std_logic lab=STO-b_RCL+b}
C {devices/lab_pin.sym} 460 560 1 0 {name=p72 sig_type=std_logic lab=STO+b_RCL-b}
C {devices/lab_pin.sym} 1240 560 1 0 {name=p51 sig_type=std_logic lab=STO+b_RCL-b}
C {devices/lab_pin.sym} -820 530 1 0 {name=p70 sig_type=std_logic lab=STO+b_RCL-b}
C {devices/lab_pin.sym} -1600 490 1 0 {name=p46 sig_type=std_logic lab=STO+b_RCL-b}
C {devices/lab_pin.sym} 670 560 1 0 {name=p74 sig_type=std_logic lab=STO-b_RCL+b}
C {devices/lab_pin.sym} 1420 560 1 0 {name=p25 sig_type=std_logic lab=STO-b_RCL+b}
C {devices/lab_pin.sym} -1560 490 1 0 {name=p29 sig_type=std_logic lab=STO-_RCL+}
C {devices/lab_pin.sym} -510 530 1 0 {name=p30 sig_type=std_logic lab=STO-_RCL+}
C {devices/lab_pin.sym} 1540 560 1 0 {name=p24 sig_type=std_logic lab=STO-_RCL+}
C {devices/lab_pin.sym} 500 560 1 0 {name=p47 sig_type=std_logic lab=STO-_RCL+}
C {devices/lab_pin.sym} -1730 490 1 0 {name=p45 sig_type=std_logic lab=STO+_RCL-}
C {devices/lab_pin.sym} -730 530 1 0 {name=p53 sig_type=std_logic lab=STO+_RCL-}
C {devices/lab_pin.sym} 320 560 1 0 {name=p56 sig_type=std_logic lab=STO+_RCL-}
C {devices/lab_pin.sym} 1380 560 1 0 {name=p52 sig_type=std_logic lab=STO+_RCL-}
C {madvlsi/ammeter1.sym} -630 -410 1 0 {name=VCompOut}
C {madvlsi/gnd.sym} 2050 880 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} 2050 820 1 0 {name=p104 sig_type=std_logic lab=PRE}
C {madvlsi/gnd.sym} 2050 740 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} 2050 680 1 0 {name=p105 sig_type=std_logic lab=SH}
C {madvlsi/gnd.sym} 2050 590 0 0 {name=l14 lab=GND}
C {devices/lab_pin.sym} 2050 530 1 0 {name=p106 sig_type=std_logic lab=SEN}
C {madvlsi/vsource.sym} 2050 710 0 0 {name=VSH
value="pulse(0 1.8 500n 100n 100n 300n 1500n 8)"}
C {madvlsi/vsource.sym} 2050 560 0 0 {name=VSEN
value="pulse(0 1.8 1100n 100n 100n 300n 1500n 8)"}
C {madvlsi/vsource.sym} 2050 850 0 0 {name=VPRE
value="pwl(0 0 100n 1.8 400n 1.8 500n 0)"}
C {madvlsi/vsource.sym} 2360 820 0 0 {name=VRST
value=1}
C {madvlsi/gnd.sym} 2360 850 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} 2360 790 1 0 {name=p107 sig_type=std_logic lab=RST}
C {madvlsi/vsource.sym} 2360 640 0 0 {name=Vd
value="pulse(0 1.8 1000n 200n 200n 400n 1500n)"}
C {madvlsi/gnd.sym} 2360 670 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} 2360 610 1 0 {name=p69 sig_type=std_logic lab=D}
