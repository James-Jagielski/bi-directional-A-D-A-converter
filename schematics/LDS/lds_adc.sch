v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {A/D} 3900 -1750 0 0 1 1 {}
T {ENAD = 1: A/D
ENAD = 0: D/A} 3890 -1940 0 0 0.7 0.7 {}
N 2330 -2020 2350 -2020 {
lab=#net1}
N 2410 -2020 2430 -2020 {
lab=VDD}
N 2490 -2020 2510 -2020 {
lab=#net2}
N 2330 -1880 2350 -1880 {
lab=#net3}
N 2410 -1880 2430 -1880 {
lab=GND}
N 2490 -1880 2510 -1880 {
lab=#net4}
N 2380 -1990 2380 -1910 {
lab=CompOutb}
N 2460 -1990 2460 -1910 {
lab=CompOut}
N 2420 -2040 2420 -2020 {
lab=VDD}
N 2420 -1880 2420 -1860 {
lab=GND}
N 2300 -2070 2300 -2050 {
lab=ENADb}
N 2300 -1850 2300 -1810 {
lab=ENAD}
N 2270 -2020 2270 -1880 {
lab=D}
N 2570 -2020 2570 -1880 {
lab=Db}
N 1880 -2030 1900 -2030 {
lab=VDD}
N 1960 -2030 1980 -2030 {
lab=#net5}
N 2040 -2030 2060 -2030 {
lab=VDD}
N 1850 -2000 1850 -1990 {
lab=#net5}
N 1880 -1860 1900 -1860 {
lab=#net6}
N 1960 -1860 1980 -1860 {
lab=GND}
N 2040 -1860 2060 -1860 {
lab=#net7}
N 1970 -1860 1970 -1840 {
lab=GND}
N 1730 -1860 1730 -1840 {
lab=GND}
N 1930 -1900 1930 -1890 {
lab=D}
N 1930 -1900 2010 -1900 {
lab=D}
N 2010 -1900 2010 -1890 {
lab=D}
N 1850 -1830 1850 -1800 {
lab=SEN}
N 1850 -1800 2090 -1800 {
lab=SEN}
N 2090 -1830 2090 -1800 {
lab=SEN}
N 1790 -2030 1790 -1860 {
lab=STO-_RCL+}
N 1820 -1990 1820 -1860 {
lab=#net5}
N 1820 -1990 1850 -1990 {
lab=#net5}
N 1790 -2030 1820 -2030 {
lab=STO-_RCL+}
N 2010 -2000 2010 -1900 {
lab=D}
N 1850 -1960 1850 -1830 {
lab=SEN}
N 1850 -1960 1930 -1960 {
lab=SEN}
N 1930 -2000 1930 -1960 {
lab=SEN}
N 1760 -2130 1760 -1890 {
lab=Vcp}
N 1760 -2130 2090 -2130 {
lab=Vcp}
N 2090 -2130 2090 -2060 {
lab=Vcp}
N 1790 -1860 1790 -1760 {
lab=STO-_RCL+}
N 2780 -2030 2800 -2030 {
lab=VDD}
N 2860 -2030 2880 -2030 {
lab=#net8}
N 2940 -2030 2960 -2030 {
lab=VDD}
N 2790 -2050 2790 -2030 {
lab=VDD}
N 2950 -2050 2950 -2030 {
lab=VDD}
N 2780 -1860 2800 -1860 {
lab=#net9}
N 2860 -1860 2880 -1860 {
lab=GND}
N 2940 -1860 2960 -1860 {
lab=#net10}
N 2870 -1860 2870 -1840 {
lab=GND}
N 2830 -1900 2830 -1890 {
lab=Db}
N 2830 -1900 2910 -1900 {
lab=Db}
N 2910 -1900 2910 -1890 {
lab=Db}
N 2750 -1830 2750 -1800 {
lab=SEN}
N 2750 -1800 2990 -1800 {
lab=SEN}
N 2990 -1830 2990 -1800 {
lab=SEN}
N 2870 -2100 2870 -2030 {
lab=#net8}
N 3110 -1860 3110 -1840 {
lab=GND}
N 2870 -2100 2990 -2100 {
lab=#net8}
N 2990 -2100 2990 -2000 {
lab=#net8}
N 3020 -2030 3050 -2030 {
lab=STO+_RCL-}
N 3050 -2030 3050 -1860 {
lab=STO+_RCL-}
N 3050 -1860 3050 -1760 {
lab=STO+_RCL-}
N 2720 -1860 2720 -1760 {
lab=STO+b_RCL-b}
N 2830 -2000 2830 -1900 {
lab=Db}
N 2990 -2000 2990 -1990 {
lab=#net8}
N 3020 -1990 3020 -1860 {
lab=#net8}
N 2990 -1990 3020 -1990 {
lab=#net8}
N 2990 -1960 2990 -1830 {
lab=SEN}
N 2910 -1960 2990 -1960 {
lab=SEN}
N 2910 -2000 2910 -1960 {
lab=SEN}
N 3080 -2120 3080 -1890 {
lab=Vcp}
N 3080 -2130 3080 -2120 {
lab=Vcp}
N 2750 -2130 3080 -2130 {
lab=Vcp}
N 2750 -2130 2750 -2060 {
lab=Vcp}
N 2720 -2030 2720 -1860 {
lab=STO+b_RCL-b}
N 2570 -1950 2830 -1950 {
lab=Db}
N 2090 -2130 2750 -2130 {
lab=Vcp}
N 2090 -1800 2750 -1800 {
lab=SEN}
N 1780 -260 1800 -260 {
lab=#net11}
N 1860 -260 1880 -260 {
lab=#net12}
N 1940 -260 1960 -260 {
lab=#net11}
N 2020 -260 2040 -260 {
lab=#net12}
N 2100 -260 2120 -260 {
lab=#net11}
N 2180 -260 2200 -260 {
lab=#net12}
N 2260 -260 2280 -260 {
lab=#net11}
N 980 -260 1000 -260 {
lab=#net11}
N 1060 -260 1080 -260 {
lab=#net12}
N 1140 -260 1160 -260 {
lab=#net11}
N 1220 -260 1240 -260 {
lab=#net12}
N 1300 -260 1320 -260 {
lab=#net11}
N 1380 -260 1400 -260 {
lab=#net12}
N 1460 -260 1480 -260 {
lab=#net11}
N 1620 -260 1640 -260 {
lab=Vb}
N 950 -290 2310 -290 {
lab=Vb}
N 1540 -260 1540 -220 {
lab=#net12}
N 920 -220 1540 -220 {
lab=#net12}
N 920 -260 920 -220 {
lab=#net12}
N 1230 -260 1230 -220 {
lab=#net12}
N 1070 -260 1070 -220 {
lab=#net12}
N 1390 -260 1390 -220 {
lab=#net12}
N 990 -320 990 -260 {
lab=#net11}
N 990 -320 1470 -320 {
lab=#net11}
N 1470 -320 1470 -260 {
lab=#net11}
N 1310 -320 1310 -260 {
lab=#net11}
N 1150 -320 1150 -260 {
lab=#net11}
N 1720 -260 1720 -220 {
lab=#net12}
N 1720 -220 2340 -220 {
lab=#net12}
N 2340 -260 2340 -220 {
lab=#net12}
N 2030 -260 2030 -220 {
lab=#net12}
N 1870 -260 1870 -220 {
lab=#net12}
N 2190 -260 2190 -220 {
lab=#net12}
N 1790 -320 1790 -260 {
lab=#net11}
N 1790 -320 2270 -320 {
lab=#net11}
N 2270 -320 2270 -260 {
lab=#net11}
N 2110 -320 2110 -260 {
lab=#net11}
N 1950 -320 1950 -260 {
lab=#net11}
N 1470 -320 1790 -320 {
lab=#net11}
N 1540 -220 1720 -220 {
lab=#net12}
N 1630 -290 1630 -260 {
lab=Vb}
N 1560 -260 1560 -180 {
lab=GND}
N 1700 -260 1700 -180 {
lab=GND}
N 2430 -260 2450 -260 {
lab=VDD}
N 820 -260 840 -260 {
lab=VDD}
N 830 -320 830 -260 {
lab=VDD}
N 2440 -320 2440 -260 {
lab=VDD}
N 900 -290 900 -260 {
lab=Vb}
N 900 -290 950 -290 {
lab=Vb}
N 870 -230 870 -220 {
lab=#net12}
N 870 -220 920 -220 {
lab=#net12}
N 2400 -230 2400 -220 {
lab=#net12}
N 2340 -220 2400 -220 {
lab=#net12}
N 2370 -290 2370 -260 {
lab=Vb}
N 2310 -290 2370 -290 {
lab=Vb}
N 2400 -220 2510 -220 {
lab=#net12}
N 2480 -230 2480 -220 {
lab=#net12}
N 2510 -260 2510 -220 {
lab=#net12}
N 760 -220 870 -220 {
lab=#net12}
N 760 -260 760 -220 {
lab=#net12}
N 790 -230 790 -220 {
lab=#net12}
N 2270 -310 2560 -310 {
lab=#net11}
N 1780 -40 1800 -40 {
lab=#net13}
N 1860 -40 1880 -40 {
lab=#net14}
N 1940 -40 1960 -40 {
lab=#net13}
N 2020 -40 2040 -40 {
lab=#net14}
N 2100 -40 2120 -40 {
lab=#net13}
N 2180 -40 2200 -40 {
lab=#net14}
N 2260 -40 2280 -40 {
lab=#net13}
N 980 -40 1000 -40 {
lab=#net13}
N 1060 -40 1080 -40 {
lab=#net14}
N 1140 -40 1160 -40 {
lab=#net13}
N 1220 -40 1240 -40 {
lab=#net14}
N 1300 -40 1320 -40 {
lab=#net13}
N 1380 -40 1400 -40 {
lab=#net14}
N 1460 -40 1480 -40 {
lab=#net13}
N 1620 -40 1640 -40 {
lab=Vcp}
N 950 -70 2310 -70 {
lab=Vcp}
N 1540 -40 1540 0 {
lab=#net14}
N 920 0 1540 0 {
lab=#net14}
N 920 -40 920 0 {
lab=#net14}
N 1230 -40 1230 0 {
lab=#net14}
N 1070 -40 1070 0 {
lab=#net14}
N 1390 -40 1390 0 {
lab=#net14}
N 990 -100 990 -40 {
lab=#net13}
N 990 -100 1470 -100 {
lab=#net13}
N 1470 -100 1470 -40 {
lab=#net13}
N 1310 -100 1310 -40 {
lab=#net13}
N 1150 -100 1150 -40 {
lab=#net13}
N 1720 -40 1720 0 {
lab=#net14}
N 1720 0 2340 0 {
lab=#net14}
N 2340 -40 2340 0 {
lab=#net14}
N 2030 -40 2030 0 {
lab=#net14}
N 1870 -40 1870 0 {
lab=#net14}
N 2190 -40 2190 0 {
lab=#net14}
N 1790 -100 1790 -40 {
lab=#net13}
N 1790 -100 2270 -100 {
lab=#net13}
N 2270 -100 2270 -40 {
lab=#net13}
N 2110 -100 2110 -40 {
lab=#net13}
N 1950 -100 1950 -40 {
lab=#net13}
N 1470 -100 1790 -100 {
lab=#net13}
N 1540 0 1720 0 {
lab=#net14}
N 1630 -70 1630 -40 {
lab=Vcp}
N 1560 -40 1560 40 {
lab=GND}
N 1700 -40 1700 40 {
lab=GND}
N 2430 -40 2450 -40 {
lab=VDD}
N 820 -40 840 -40 {
lab=VDD}
N 830 -100 830 -40 {
lab=VDD}
N 2440 -100 2440 -40 {
lab=VDD}
N 900 -70 900 -40 {
lab=Vcp}
N 900 -70 950 -70 {
lab=Vcp}
N 870 -10 870 0 {
lab=#net14}
N 870 0 920 0 {
lab=#net14}
N 2400 -10 2400 0 {
lab=#net14}
N 2340 0 2400 0 {
lab=#net14}
N 2370 -70 2370 -40 {
lab=Vcp}
N 2310 -70 2370 -70 {
lab=Vcp}
N 2400 0 2510 0 {
lab=#net14}
N 2480 -10 2480 0 {
lab=#net14}
N 2510 -40 2510 0 {
lab=#net14}
N 760 0 870 0 {
lab=#net14}
N 760 -40 760 0 {
lab=#net14}
N 790 -10 790 0 {
lab=#net14}
N 2270 -90 2560 -90 {
lab=#net13}
N 2370 -360 2370 -290 {
lab=Vb}
N 740 -2100 760 -2100 {
lab=#net15}
N 820 -2100 840 -2100 {
lab=VDD}
N 980 -2100 1000 -2100 {
lab=VDD}
N 1060 -2100 1080 -2100 {
lab=#net16}
N 790 -2130 870 -2130 {
lab=#net17}
N 950 -2130 1030 -2130 {
lab=#net18}
N 900 -2130 900 -2100 {
lab=#net17}
N 870 -2130 900 -2130 {
lab=#net17}
N 920 -2130 920 -2100 {
lab=#net18}
N 920 -2130 950 -2130 {
lab=#net18}
N 710 -2070 1110 -2070 {
lab=Vcp}
N 740 -1950 760 -1950 {
lab=GND}
N 900 -1950 920 -1950 {
lab=#net19}
N 820 -1950 840 -1950 {
lab=#net17}
N 980 -1950 1000 -1950 {
lab=#net18}
N 740 -1770 760 -1770 {
lab=#net20}
N 900 -1770 920 -1770 {
lab=#net21}
N 820 -1770 840 -1770 {
lab=#net22}
N 980 -1770 1000 -1770 {
lab=GND}
N 1060 -1770 1080 -1770 {
lab=#net20}
N 1140 -1770 1160 -1770 {
lab=CompOut}
N 1140 -2100 1140 -1950 {
lab=CompOutb}
N 1220 -1900 1220 -1770 {
lab=#net23}
N 1190 -2070 1190 -1800 {
lab=ENADb}
N 1220 -2100 1220 -1900 {
lab=#net23}
N 1110 -1920 1110 -1800 {
lab=#net23}
N 1110 -1850 1220 -1850 {
lab=#net23}
N 910 -1850 910 -1770 {
lab=#net21}
N 910 -1850 1080 -1850 {
lab=#net21}
N 1080 -1950 1080 -1850 {
lab=#net21}
N 680 -1770 680 -1740 {
lab=#net22}
N 680 -1740 680 -1720 {
lab=#net22}
N 680 -1720 830 -1720 {
lab=#net22}
N 950 -1800 1070 -1800 {
lab=#net20}
N 1070 -1800 1070 -1770 {
lab=#net20}
N 830 -1720 1030 -1720 {
lab=#net22}
N 1030 -1740 1030 -1720 {
lab=#net22}
N 990 -1770 990 -1760 {
lab=GND}
N 950 -1800 950 -1740 {
lab=#net20}
N 750 -1740 950 -1740 {
lab=#net20}
N 830 -1770 830 -1720 {
lab=#net22}
N 830 -1720 830 -1700 {
lab=#net22}
N 750 -1770 750 -1740 {
lab=#net20}
N 750 -1740 750 -1700 {
lab=#net20}
N 900 -2100 900 -2030 {
lab=#net17}
N 830 -2030 900 -2030 {
lab=#net17}
N 830 -2030 830 -1950 {
lab=#net17}
N 920 -2100 920 -2030 {
lab=#net18}
N 920 -2030 990 -2030 {
lab=#net18}
N 990 -2030 990 -1950 {
lab=#net18}
N 750 -1950 750 -1940 {
lab=GND}
N 680 -1950 680 -1900 {
lab=#net19}
N 680 -1900 910 -1900 {
lab=#net19}
N 910 -1950 910 -1900 {
lab=#net19}
N 1060 -1950 1060 -1940 {
lab=GND}
N 710 -1980 1030 -1980 {
lab=Vb}
N 830 -2150 830 -2100 {
lab=VDD}
N 990 -2150 990 -2100 {
lab=VDD}
N 1160 -2150 1160 -2100 {
lab=VDD}
N 790 -1820 790 -1800 {
lab=ENADb}
N 790 -1820 1190 -1820 {
lab=ENADb}
N 250 -1210 250 -1170 {
lab=PREb}
N 220 -1240 220 -1140 {
lab=PRE}
N 250 -1190 270 -1190 {
lab=PREb}
N 1440 -1900 1440 -1860 {
lab=ENADb}
N 1410 -1930 1410 -1830 {
lab=ENAD}
N 1390 -1880 1410 -1880 {
lab=ENAD}
N 1440 -1880 1460 -1880 {
lab=ENADb}
N 320 -1800 710 -1800 {
lab=RST}
N 20 -1350 480 -1350 {
lab=Vref-}
N 2980 -1350 3450 -1350 {
lab=Vref+}
N 1110 -2130 1110 -2070 {
lab=Vcp}
N 1110 -2130 1760 -2130 {
lab=Vcp}
N 2560 -90 2560 -30 {
lab=#net13}
N 2370 -70 2700 -70 {
lab=Vcp}
N 2910 -2260 2910 -2000 {
lab=SEN}
N 2370 -420 2450 -420 {
lab=Vb}
N 2370 -420 2370 -360 {
lab=Vb}
N 900 -670 900 -290 {
lab=Vb}
N 870 -1920 870 -1880 {
lab=CompOutb}
N 320 -1880 870 -1880 {
lab=CompOutb}
N 950 -1920 950 -1880 {
lab=C+}
N 950 -1880 1310 -1880 {
lab=C+}
N 3050 -1760 3090 -1760 {
lab=STO+_RCL-}
N 650 -1980 710 -1980 {
lab=Vb}
N 1790 -1760 1860 -1760 {
lab=STO-_RCL+}
N 680 -2190 680 -2100 {
lab=CompOut}
N 680 -2190 2460 -2190 {
lab=CompOut}
N 2460 -2190 2460 -1990 {
lab=CompOut}
N 1150 -1740 1260 -1740 {
lab=CompOut}
N 1260 -2190 1260 -1740 {
lab=CompOut}
N 1150 -1770 1150 -1740 {
lab=CompOut}
N 1140 -2110 1140 -2100 {
lab=CompOutb}
N 1140 -2110 2380 -2110 {
lab=CompOutb}
N 2380 -2110 2380 -1990 {
lab=CompOutb}
N 2780 -1760 2780 -1380 {
lab=STO+b_RCL-b}
N 2720 -1760 2780 -1760 {
lab=STO+b_RCL-b}
N -90 -1190 220 -1190 {
lab=PRE}
N 270 -1190 330 -1190 {
lab=PREb}
N 1850 -2060 1850 -2000 {
lab=#net5}
N 1850 -2060 1970 -2060 {
lab=#net5}
N 1970 -2060 1970 -2030 {
lab=#net5}
N 1190 -2070 2300 -2070 {
lab=ENADb}
N 2540 -2070 2540 -2050 {
lab=ENADb}
N 2300 -2070 2540 -2070 {
lab=ENADb}
N 2300 -1810 2300 -1650 {
lab=ENAD}
N 870 -1650 2300 -1650 {
lab=ENAD}
N 870 -1800 870 -1650 {
lab=ENAD}
N 2300 -1820 2540 -1820 {
lab=ENAD}
N 2540 -1850 2540 -1820 {
lab=ENAD}
N 1310 -1880 1310 -1610 {
lab=C+}
N 1460 -2070 1460 -1880 {
lab=ENADb}
N 1390 -1880 1390 -1650 {
lab=ENAD}
N 2130 -2030 2130 -1760 {
lab=STO-b_RCL+b}
N 2120 -2030 2130 -2030 {
lab=STO-b_RCL+b}
N 2120 -1860 2130 -1860 {
lab=STO-b_RCL+b}
N 2130 -1760 2160 -1760 {
lab=STO-b_RCL+b}
N 2630 -2020 2650 -2020 {
lab=VDD}
N 2630 -1880 2650 -1880 {
lab=GND}
N 2600 -1990 2600 -1910 {
lab=D}
N 2270 -1970 2600 -1970 {
lab=D}
N 2010 -1970 2270 -1970 {
lab=D}
N 2560 -90 2560 -30 {
lab=#net13}
N 2540 -280 2540 -250 {
lab=GND}
N 2540 -250 2540 -200 {
lab=GND}
N 2540 30 2540 80 {
lab=GND}
N 2540 0 2540 30 {
lab=GND}
N 2670 30 2670 80 {
lab=GND}
N 2670 0 2670 30 {
lab=GND}
N 2830 30 2830 80 {
lab=GND}
N 2830 0 2830 30 {
lab=GND}
N 2560 -30 2690 -30 {
lab=#net13}
N 2690 -30 2850 -30 {
lab=#net13}
N 880 -1350 920 -1350 {
lab=VDD}
N 850 -1380 950 -1380 {
lab=#net24}
N 1090 -1350 1130 -1350 {
lab=VDD}
N 1060 -1380 1160 -1380 {
lab=#net25}
N 1190 -1350 1220 -1350 {
lab=#net26}
N 570 -1340 630 -1340 {
lab=#net27}
N 630 -1350 630 -1340 {
lab=#net27}
N 570 -1050 570 -1040 {
lab=#net27}
N 570 -1050 630 -1050 {
lab=#net27}
N 630 -1050 630 -1040 {
lab=#net27}
N 600 -1340 600 -1240 {
lab=#net27}
N 600 -1240 600 -1050 {
lab=#net27}
N 1380 -1350 1380 -1340 {
lab=C-}
N 1380 -1340 1440 -1340 {
lab=C-}
N 1440 -1350 1440 -1340 {
lab=C-}
N 1380 -1050 1380 -1040 {
lab=C-}
N 1380 -1050 1440 -1050 {
lab=C-}
N 1440 -1050 1440 -1040 {
lab=C-}
N 1420 -1340 1420 -1240 {
lab=C-}
N 1420 -1240 1420 -1050 {
lab=C-}
N 630 -1350 650 -1350 {
lab=#net27}
N 630 -1040 650 -1040 {
lab=#net27}
N 1360 -1350 1380 -1350 {
lab=C-}
N 1360 -1040 1380 -1040 {
lab=C-}
N 1300 -1350 1300 -1260 {
lab=#net28}
N 1300 -1180 1300 -1040 {
lab=#net28}
N 1300 -1260 1300 -1220 {
lab=#net28}
N 1300 -1220 1300 -1180 {
lab=#net28}
N 710 -1350 730 -1350 {
lab=#net29}
N 630 -1300 850 -1300 {
lab=#net25}
N 1160 -1300 1390 -1300 {
lab=#net24}
N 950 -1380 980 -1380 {
lab=#net24}
N 980 -1380 980 -1350 {
lab=#net24}
N 1030 -1380 1030 -1350 {
lab=#net25}
N 1030 -1380 1060 -1380 {
lab=#net25}
N 540 -1350 540 -1040 {
lab=#net27}
N 1470 -1350 1470 -1040 {
lab=C-}
N 480 -1350 480 -1040 {
lab=Vref-}
N 1530 -1350 1530 -1040 {
lab=Vref-}
N 570 -1300 630 -1300 {
lab=#net25}
N 570 -1300 570 -1200 {
lab=#net25}
N 1390 -1300 1450 -1300 {
lab=#net24}
N 1450 -1300 1450 -1200 {
lab=#net24}
N 630 -1280 630 -1200 {
lab=#net30}
N 630 -1280 970 -1280 {
lab=#net30}
N 970 -1280 1390 -1280 {
lab=#net30}
N 1390 -1280 1390 -1200 {
lab=#net30}
N 1280 -1350 1300 -1350 {
lab=#net28}
N 570 -1350 570 -1340 {
lab=#net27}
N 540 -1350 570 -1350 {
lab=#net27}
N 540 -1040 570 -1040 {
lab=#net27}
N 1440 -1350 1470 -1350 {
lab=C-}
N 1440 -1040 1470 -1040 {
lab=C-}
N 790 -1350 820 -1350 {
lab=#net31}
N 760 -1410 760 -1380 {
lab=Vcp}
N 760 -1410 1250 -1410 {
lab=Vcp}
N 1250 -1410 1250 -1380 {
lab=Vcp}
N 850 -1300 1030 -1300 {
lab=#net25}
N 1030 -1350 1030 -1300 {
lab=#net25}
N 1110 -1300 1160 -1300 {
lab=#net24}
N 1110 -1320 1110 -1300 {
lab=#net24}
N 980 -1320 1110 -1320 {
lab=#net24}
N 980 -1350 980 -1320 {
lab=#net24}
N 690 -1200 690 -1170 {
lab=GND}
N 1330 -1010 1330 -950 {
lab=STO+_RCL-}
N 600 -950 1330 -950 {
lab=STO+_RCL-}
N 600 -1010 600 -950 {
lab=STO+_RCL-}
N 1330 -1450 1330 -1380 {
lab=STO+b_RCL-b}
N 600 -1450 1330 -1450 {
lab=STO+b_RCL-b}
N 600 -1450 600 -1380 {
lab=STO+b_RCL-b}
N 1410 -1480 1410 -1380 {
lab=STO-b_RCL+b}
N 680 -1480 1410 -1480 {
lab=STO-b_RCL+b}
N 680 -1480 680 -1380 {
lab=STO-b_RCL+b}
N 510 -1510 510 -1380 {
lab=PREb}
N 510 -1510 1500 -1510 {
lab=PREb}
N 1500 -1510 1500 -1380 {
lab=PREb}
N 480 -1040 480 -890 {
lab=Vref-}
N 480 -890 1530 -890 {
lab=Vref-}
N 1530 -1040 1530 -890 {
lab=Vref-}
N 680 -930 1410 -930 {
lab=STO-_RCL+}
N 680 -1010 680 -930 {
lab=STO-_RCL+}
N 1410 -1010 1410 -930 {
lab=STO-_RCL+}
N 510 -910 1500 -910 {
lab=PRE}
N 1500 -1010 1500 -910 {
lab=PRE}
N 510 -1010 510 -910 {
lab=PRE}
N 720 -1350 720 -1040 {
lab=#net29}
N 710 -1040 720 -1040 {
lab=#net29}
N 910 -1200 930 -1200 {
lab=#net29}
N 910 -1040 930 -1040 {
lab=#net32}
N 1070 -1040 1090 -1040 {
lab=#net33}
N 1070 -1200 1090 -1200 {
lab=#net28}
N 990 -1200 1010 -1200 {
lab=#net34}
N 990 -1040 1010 -1040 {
lab=#net35}
N 880 -1230 1120 -1230 {
lab=#net34}
N 1000 -1230 1000 -1200 {
lab=#net34}
N 960 -1170 960 -1070 {
lab=Db}
N 1040 -1170 1040 -1070 {
lab=D}
N 880 -1010 1120 -1010 {
lab=#net35}
N 1000 -1040 1000 -1010 {
lab=#net35}
N 850 -1200 850 -1070 {
lab=#net32}
N 850 -1070 920 -1070 {
lab=#net32}
N 920 -1070 920 -1040 {
lab=#net32}
N 1150 -1200 1150 -1070 {
lab=#net33}
N 1080 -1070 1150 -1070 {
lab=#net33}
N 1080 -1070 1080 -1040 {
lab=#net33}
N 1080 -1250 1080 -1200 {
lab=#net28}
N 1080 -1250 1300 -1250 {
lab=#net28}
N 920 -1250 920 -1200 {
lab=#net29}
N 720 -1250 920 -1250 {
lab=#net29}
N 1040 -1260 1040 -1170 {
lab=D}
N 1040 -1260 1210 -1260 {
lab=D}
N 1210 -1560 1210 -1260 {
lab=D}
N 960 -1260 960 -1170 {
lab=Db}
N 810 -1260 960 -1260 {
lab=Db}
N 810 -1550 810 -1260 {
lab=Db}
N 1720 -1190 1720 -1000 {
lab=SH}
N 1670 -1120 1690 -1120 {
lab=SHb}
N 1670 -1220 1670 -1120 {
lab=SHb}
N 1670 -1220 1690 -1220 {
lab=SHb}
N 1670 -1380 1670 -1220 {
lab=SHb}
N 1670 -1380 1720 -1380 {
lab=SHb}
N 1630 -1350 1630 -1280 {
lab=C-}
N 1630 -1350 1690 -1350 {
lab=C-}
N 1630 -1280 1630 -1030 {
lab=C-}
N 1630 -1030 1690 -1030 {
lab=C-}
N 1750 -1220 1770 -1220 {
lab=VDD}
N 1750 -1120 1770 -1120 {
lab=GND}
N 1750 -1030 1830 -1030 {
lab=C+}
N 1830 -1350 1830 -1030 {
lab=C+}
N 1750 -1350 1830 -1350 {
lab=C+}
N 1470 -1260 1630 -1260 {
lab=C-}
N 2330 -1350 2370 -1350 {
lab=VDD}
N 2300 -1380 2400 -1380 {
lab=#net36}
N 2540 -1350 2580 -1350 {
lab=VDD}
N 2510 -1380 2610 -1380 {
lab=#net37}
N 2640 -1350 2670 -1350 {
lab=#net38}
N 2020 -1340 2080 -1340 {
lab=C+}
N 2080 -1350 2080 -1340 {
lab=C+}
N 2020 -1050 2020 -1040 {
lab=C+}
N 2020 -1050 2080 -1050 {
lab=C+}
N 2080 -1050 2080 -1040 {
lab=C+}
N 2050 -1340 2050 -1240 {
lab=C+}
N 2050 -1240 2050 -1050 {
lab=C+}
N 2830 -1350 2830 -1340 {
lab=#net39}
N 2830 -1340 2890 -1340 {
lab=#net39}
N 2890 -1350 2890 -1340 {
lab=#net39}
N 2830 -1050 2830 -1040 {
lab=#net39}
N 2830 -1050 2890 -1050 {
lab=#net39}
N 2890 -1050 2890 -1040 {
lab=#net39}
N 2870 -1340 2870 -1240 {
lab=#net39}
N 2870 -1240 2870 -1050 {
lab=#net39}
N 2080 -1350 2100 -1350 {
lab=C+}
N 2080 -1040 2100 -1040 {
lab=C+}
N 2810 -1350 2830 -1350 {
lab=#net39}
N 2810 -1040 2830 -1040 {
lab=#net39}
N 2750 -1350 2750 -1260 {
lab=#net40}
N 2750 -1180 2750 -1040 {
lab=#net40}
N 2750 -1260 2750 -1220 {
lab=#net40}
N 2750 -1220 2750 -1180 {
lab=#net40}
N 2160 -1350 2180 -1350 {
lab=#net41}
N 2080 -1300 2300 -1300 {
lab=#net37}
N 2610 -1300 2840 -1300 {
lab=#net36}
N 2400 -1380 2430 -1380 {
lab=#net36}
N 2430 -1380 2430 -1350 {
lab=#net36}
N 2480 -1380 2480 -1350 {
lab=#net37}
N 2480 -1380 2510 -1380 {
lab=#net37}
N 1990 -1350 1990 -1040 {
lab=C+}
N 2920 -1350 2920 -1040 {
lab=#net39}
N 1930 -1350 1930 -1040 {
lab=Vref+}
N 2980 -1350 2980 -1040 {
lab=Vref+}
N 2020 -1300 2080 -1300 {
lab=#net37}
N 2020 -1300 2020 -1200 {
lab=#net37}
N 2840 -1300 2900 -1300 {
lab=#net36}
N 2900 -1300 2900 -1200 {
lab=#net36}
N 2080 -1280 2080 -1200 {
lab=#net42}
N 2080 -1280 2420 -1280 {
lab=#net42}
N 2420 -1280 2840 -1280 {
lab=#net42}
N 2840 -1280 2840 -1200 {
lab=#net42}
N 2730 -1350 2750 -1350 {
lab=#net40}
N 2020 -1350 2020 -1340 {
lab=C+}
N 1990 -1350 2020 -1350 {
lab=C+}
N 1990 -1040 2020 -1040 {
lab=C+}
N 2890 -1350 2920 -1350 {
lab=#net39}
N 2890 -1040 2920 -1040 {
lab=#net39}
N 2240 -1350 2270 -1350 {
lab=#net43}
N 2210 -1410 2210 -1380 {
lab=Vcp}
N 2210 -1410 2700 -1410 {
lab=Vcp}
N 2700 -1410 2700 -1380 {
lab=Vcp}
N 2300 -1300 2480 -1300 {
lab=#net37}
N 2480 -1350 2480 -1300 {
lab=#net37}
N 2560 -1300 2610 -1300 {
lab=#net36}
N 2560 -1320 2560 -1300 {
lab=#net36}
N 2430 -1320 2560 -1320 {
lab=#net36}
N 2430 -1350 2430 -1320 {
lab=#net36}
N 2780 -1200 2780 -1170 {
lab=GND}
N 2780 -1010 2780 -950 {
lab=STO+_RCL-}
N 2050 -950 2780 -950 {
lab=STO+_RCL-}
N 2050 -1010 2050 -950 {
lab=STO+_RCL-}
N 2780 -1450 2780 -1380 {
lab=STO+b_RCL-b}
N 2050 -1450 2780 -1450 {
lab=STO+b_RCL-b}
N 2050 -1450 2050 -1380 {
lab=STO+b_RCL-b}
N 2860 -1480 2860 -1380 {
lab=STO-b_RCL+b}
N 2130 -1480 2860 -1480 {
lab=STO-b_RCL+b}
N 2130 -1480 2130 -1380 {
lab=STO-b_RCL+b}
N 1960 -1510 1960 -1380 {
lab=PREb}
N 1960 -1510 2950 -1510 {
lab=PREb}
N 2950 -1510 2950 -1380 {
lab=PREb}
N 1930 -1040 1930 -890 {
lab=Vref+}
N 1930 -890 2980 -890 {
lab=Vref+}
N 2980 -1040 2980 -890 {
lab=Vref+}
N 2130 -930 2860 -930 {
lab=STO-_RCL+}
N 2130 -1010 2130 -930 {
lab=STO-_RCL+}
N 2860 -1010 2860 -930 {
lab=STO-_RCL+}
N 1960 -910 2950 -910 {
lab=PRE}
N 2950 -1010 2950 -910 {
lab=PRE}
N 1960 -1010 1960 -910 {
lab=PRE}
N 2170 -1350 2170 -1040 {
lab=#net41}
N 2160 -1040 2170 -1040 {
lab=#net41}
N 2360 -1200 2380 -1200 {
lab=#net41}
N 2360 -1040 2380 -1040 {
lab=#net44}
N 2520 -1040 2540 -1040 {
lab=#net45}
N 2520 -1200 2540 -1200 {
lab=#net40}
N 2440 -1200 2460 -1200 {
lab=#net46}
N 2440 -1040 2460 -1040 {
lab=#net47}
N 2330 -1230 2570 -1230 {
lab=#net46}
N 2450 -1230 2450 -1200 {
lab=#net46}
N 2410 -1170 2410 -1070 {
lab=Db}
N 2490 -1170 2490 -1070 {
lab=D}
N 2330 -1010 2570 -1010 {
lab=#net47}
N 2450 -1040 2450 -1010 {
lab=#net47}
N 2300 -1200 2300 -1070 {
lab=#net44}
N 2300 -1070 2370 -1070 {
lab=#net44}
N 2370 -1070 2370 -1040 {
lab=#net44}
N 2600 -1200 2600 -1070 {
lab=#net45}
N 2530 -1070 2600 -1070 {
lab=#net45}
N 2530 -1070 2530 -1040 {
lab=#net45}
N 2530 -1250 2530 -1200 {
lab=#net40}
N 2530 -1250 2750 -1250 {
lab=#net40}
N 2370 -1250 2370 -1200 {
lab=#net41}
N 2170 -1250 2370 -1250 {
lab=#net41}
N 2490 -1260 2490 -1170 {
lab=D}
N 2490 -1260 2660 -1260 {
lab=D}
N 2660 -1560 2660 -1260 {
lab=D}
N 2410 -1260 2410 -1170 {
lab=Db}
N 2260 -1260 2410 -1260 {
lab=Db}
N 2260 -1550 2260 -1260 {
lab=Db}
N 1830 -1260 1990 -1260 {
lab=C+}
N 1500 -1510 1960 -1510 {
lab=PREb}
N 1330 -1450 2050 -1450 {
lab=STO+b_RCL-b}
N 1410 -1480 2130 -1480 {
lab=STO-b_RCL+b}
N 1500 -910 1960 -910 {
lab=PRE}
N 1330 -950 2050 -950 {
lab=STO+_RCL-}
N 1410 -930 2130 -930 {
lab=STO-_RCL+}
N 220 -910 510 -910 {
lab=PRE}
N 220 -1140 220 -910 {
lab=PRE}
N 330 -1510 330 -1190 {
lab=PREb}
N 330 -1510 510 -1510 {
lab=PREb}
N 660 -1170 660 -1110 {
lab=Vb}
N 450 -1110 660 -1110 {
lab=Vb}
N 450 -1110 450 -670 {
lab=Vb}
N 450 -670 900 -670 {
lab=Vb}
N 2780 -950 3050 -950 {
lab=STO+_RCL-}
N 3050 -1760 3050 -950 {
lab=STO+_RCL-}
N 2810 -1170 3020 -1170 {
lab=Vb}
N 3020 -1170 3020 -840 {
lab=Vb}
N 2450 -420 3020 -420 {
lab=Vb}
N 3020 -840 3020 -420 {
lab=Vb}
N 450 -1970 450 -1110 {
lab=Vb}
N 450 -1980 450 -1970 {
lab=Vb}
N 450 -1980 650 -1980 {
lab=Vb}
N 2700 -1410 3140 -1410 {
lab=Vcp}
N 3140 -1410 3140 -90 {
lab=Vcp}
N 2700 -70 3140 -70 {
lab=Vcp}
N 3140 -90 3140 -70 {
lab=Vcp}
N 1250 -1410 2210 -1410 {
lab=Vcp}
N 3140 -1890 3140 -1410 {
lab=Vcp}
N 3080 -1890 3140 -1890 {
lab=Vcp}
N 2130 -1760 2130 -1480 {
lab=STO-b_RCL+b}
N 2600 -1910 2600 -1560 {
lab=D}
N 2600 -1560 2660 -1560 {
lab=D}
N 810 -1550 2260 -1550 {
lab=Db}
N 2260 -1550 2570 -1550 {
lab=Db}
N 2570 -1880 2570 -1550 {
lab=Db}
N 1210 -1570 1210 -1560 {
lab=D}
N 1210 -1570 1930 -1570 {
lab=D}
N 1930 -1890 1930 -1570 {
lab=D}
N 1830 -1610 1830 -1350 {
lab=C+}
N 1310 -1610 1830 -1610 {
lab=C+}
N 1860 -1760 1860 -930 {
lab=STO-_RCL+}
C {devices/code_shown.sym} 3880 -490 0 0 {name=SPICE only_toplevel=false value=".param W = 1
.param L = .15
.ic v(CompOut) = 1.8
.control
  set wr_singlescale
  set wr_vecnames
  let min_input = 0.5
  let run = 0
  while run < 256
    let analog_input = min_input + run/255
    alter VAin $&analog_input
    save all
    tran 50n 410u
    wrdata ~/Documents/bi-directional-A-D-A-converter/simulations/A_in\{$&run\\\}_lds_MIM.txt v(sh) v(pre) v(rst) V(sen) V(d) v(CompOut) v(AIn) v(C+) v(C-) v(vb) v(vcp)
    let run = run + 1
  end
  quit
.endc"
}
C {madvlsi/vsource.sym} 3920 -990 0 0 {name=VDD
value=1.8}
C {madvlsi/vdd.sym} 3920 -1020 0 0 {name=l55 lab=VDD}
C {madvlsi/gnd.sym} 3920 -960 0 0 {name=l56 lab=GND}
C {madvlsi/vsource.sym} 4060 -810 0 0 {name=Vrefp
value=1.5}
C {madvlsi/gnd.sym} 4060 -780 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} 4060 -840 1 0 {name=p102 sig_type=std_logic lab=Vref+}
C {madvlsi/vsource.sym} 4130 -810 0 0 {name=Vrefn
value=0.5}
C {madvlsi/gnd.sym} 4130 -780 0 0 {name=l58 lab=GND}
C {devices/lab_pin.sym} 4130 -840 1 0 {name=p103 sig_type=std_logic lab=Vref-}
C {madvlsi/vsource.sym} 4290 -1890 0 0 {name=VENAD
value=1.8}
C {madvlsi/gnd.sym} 4290 -1860 0 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} 4290 -1920 1 0 {name=p157 sig_type=std_logic lab=ENAD}
C {madvlsi/gnd.sym} 3930 -1190 0 0 {name=l60 lab=GND}
C {devices/lab_pin.sym} 3930 -1250 1 0 {name=p104 sig_type=std_logic lab=PRE}
C {madvlsi/gnd.sym} 3930 -1330 0 0 {name=l61 lab=GND}
C {devices/lab_pin.sym} 3930 -1390 1 0 {name=p105 sig_type=std_logic lab=SH}
C {madvlsi/gnd.sym} 3930 -1480 0 0 {name=l62 lab=GND}
C {devices/lab_pin.sym} 3930 -1540 1 0 {name=p106 sig_type=std_logic lab=SEN}
C {madvlsi/vsource.sym} 3930 -1360 0 0 {name=VSH
value="pulse(0 1.8 6u 1n 1n 5u 50u 9)"}
C {madvlsi/vsource.sym} 3930 -1510 0 0 {name=VSEN
value="pulse(0 1.8 18u 1n 1n 31u 50u 8)"}
C {madvlsi/vsource.sym} 3930 -1220 0 0 {name=VPRE
value="pwl(0 0 1u 0 1u 1.8 5u 1.8 5u 0)"}
C {madvlsi/vsource.sym} 4240 -1250 0 0 {name=VRST
value="pulse(0 1.8 12u 1n 1n 5u 50u 9)"}
C {madvlsi/gnd.sym} 4240 -1220 0 0 {name=l63 lab=GND}
C {devices/lab_pin.sym} 4240 -1280 1 0 {name=p107 sig_type=std_logic lab=RST}
C {madvlsi/vsource.sym} 4240 -1430 0 0 {name=VAin
value=1.6}
C {madvlsi/gnd.sym} 4240 -1400 0 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} 4240 -1460 1 0 {name=p1 sig_type=std_logic lab=AIn}
C {madvlsi/tt_models.sym} 3880 -660 0 0 {
name=TT_MODELS
only_toplevel=false
value=".option wnflag=1
.param MC_SWITCH=0.0
.lib ~/skywater/skywater-pdk/libraries/sky130_fd_pr_ngspice/latest/models/sky130.lib.spice tt"
}
C {madvlsi/pmos3.sym} 2300 -2020 1 0 {name=M1
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2380 -2020 3 0 {name=M2
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2460 -2020 3 0 {name=M3
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2540 -2020 1 0 {name=M4
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2300 -1880 3 0 {name=M5
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2380 -1880 1 0 {name=M6
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2460 -1880 1 0 {name=M7
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2540 -1880 3 0 {name=M8
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 2420 -2040 0 0 {name=l1 lab=VDD}
C {madvlsi/gnd.sym} 2420 -1860 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 2220 -1970 1 0 {name=p5 sig_type=std_logic lab=D}
C {devices/lab_pin.sym} 2670 -1950 1 0 {name=p6 sig_type=std_logic lab=Db}
C {madvlsi/pmos3.sym} 1850 -2030 3 0 {name=M9
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1930 -2030 3 0 {name=M10
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2010 -2030 3 0 {name=M11
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2090 -2030 1 0 {name=M12
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1890 -2030 0 0 {name=l5 lab=VDD}
C {madvlsi/vdd.sym} 2050 -2030 0 0 {name=l6 lab=VDD}
C {madvlsi/nmos3.sym} 1850 -1860 3 0 {name=M13
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1930 -1860 1 0 {name=M14
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2010 -1860 1 0 {name=M15
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2090 -1860 3 0 {name=M16
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1970 -1840 0 0 {name=l7 lab=GND}
C {madvlsi/nmos3.sym} 1760 -1860 1 0 {name=M17
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1730 -1840 0 0 {name=l8 lab=GND}
C {madvlsi/gnd.sym} 1790 -1700 0 0 {name=l9 lab=GND}
C {madvlsi/gnd.sym} 2160 -1700 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 1790 -1760 0 0 {name=p10 sig_type=std_logic lab=STO-_RCL+}
C {devices/lab_pin.sym} 2130 -1760 0 0 {name=p11 sig_type=std_logic lab=STO-b_RCL+b}
C {devices/lab_pin.sym} 2910 -2260 1 0 {name=p13 sig_type=std_logic lab=SEN}
C {madvlsi/pmos3.sym} 2750 -2030 1 0 {name=M18
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2830 -2030 3 0 {name=M19
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2910 -2030 3 0 {name=M20
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2990 -2030 3 0 {name=M21
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 2790 -2050 0 0 {name=l11 lab=VDD}
C {madvlsi/vdd.sym} 2950 -2050 0 0 {name=l12 lab=VDD}
C {madvlsi/nmos3.sym} 2750 -1860 3 0 {name=M22
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2830 -1860 1 0 {name=M23
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2910 -1860 1 0 {name=M24
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2990 -1860 3 0 {name=M25
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2870 -1840 0 0 {name=l13 lab=GND}
C {madvlsi/nmos3.sym} 3080 -1860 1 0 {name=M26
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 3110 -1840 0 0 {name=l14 lab=GND}
C {madvlsi/gnd.sym} 2720 -1700 0 0 {name=l15 lab=GND}
C {madvlsi/gnd.sym} 3090 -1700 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} 2720 -1760 0 0 {name=p16 sig_type=std_logic lab=STO+b_RCL-b}
C {devices/lab_pin.sym} 3090 -1760 2 0 {name=p17 sig_type=std_logic lab=STO+_RCL-}
C {devices/lab_pin.sym} 20 -1350 0 0 {name=p30 sig_type=std_logic lab=Vref-}
C {devices/lab_pin.sym} 3450 -1350 2 0 {name=p57 sig_type=std_logic lab=Vref+}
C {madvlsi/nmos3.sym} 1670 -260 1 0 {name=M85
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1750 -260 1 0 {name=M86
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1830 -260 1 0 {name=M87
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1910 -260 1 0 {name=M88
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1990 -260 1 0 {name=M89
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2070 -260 1 0 {name=M90
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2150 -260 1 0 {name=M91
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2230 -260 1 0 {name=M92
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2310 -260 1 0 {name=M93
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 950 -260 1 0 {name=M94
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1030 -260 1 0 {name=M95
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1110 -260 1 0 {name=M96
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1190 -260 1 0 {name=M97
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1270 -260 1 0 {name=M98
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1350 -260 1 0 {name=M99
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1430 -260 1 0 {name=M100
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1510 -260 1 0 {name=M101
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1590 -260 1 0 {name=M102
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1560 -180 0 0 {name=l3 lab=GND}
C {madvlsi/pmos3.sym} 2400 -260 3 0 {name=M103
L=0.5
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2480 -260 3 0 {name=M104
L=0.5
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 790 -260 3 0 {name=M105
L=0.5
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 870 -260 3 0 {name=M106
L=0.5
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 830 -320 0 0 {name=l4 lab=VDD}
C {madvlsi/vdd.sym} 2440 -320 0 0 {name=l16 lab=VDD}
C {madvlsi/gnd.sym} 1700 -180 0 0 {name=l17 lab=GND}
C {madvlsi/nmos3.sym} 1670 -40 1 0 {name=M107
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1750 -40 1 0 {name=M108
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1830 -40 1 0 {name=M109
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1910 -40 1 0 {name=M110
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1990 -40 1 0 {name=M111
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2070 -40 1 0 {name=M112
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2150 -40 1 0 {name=M113
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2230 -40 1 0 {name=M114
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2310 -40 1 0 {name=M115
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 950 -40 1 0 {name=M116
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1030 -40 1 0 {name=M117
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1110 -40 1 0 {name=M118
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1190 -40 1 0 {name=M119
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1270 -40 1 0 {name=M120
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1350 -40 1 0 {name=M121
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1430 -40 1 0 {name=M122
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1510 -40 1 0 {name=M123
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1590 -40 1 0 {name=M124
L=0.5
W=6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1560 40 0 0 {name=l20 lab=GND}
C {madvlsi/pmos3.sym} 2400 -40 3 0 {name=M125
L=0.5
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2480 -40 3 0 {name=M126
L=0.5
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 790 -40 3 0 {name=M127
L=0.5
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 870 -40 3 0 {name=M128
L=0.5
W=6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 830 -100 0 0 {name=l21 lab=VDD}
C {madvlsi/vdd.sym} 2440 -100 0 0 {name=l22 lab=VDD}
C {madvlsi/gnd.sym} 1700 40 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} 900 -440 0 0 {name=p7 sig_type=std_logic lab=Vb}
C {devices/lab_pin.sym} 3140 -180 0 0 {name=p31 sig_type=std_logic lab=Vcp}
C {madvlsi/pmos3.sym} 710 -2100 1 1 {name=M129
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 790 -2100 3 1 {name=M130
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 870 -2100 3 1 {name=M131
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 950 -2100 3 1 {name=M132
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1030 -2100 3 1 {name=M133
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1110 -2100 1 1 {name=M134
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1190 -2100 1 1 {name=M135
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 830 -2150 0 0 {name=l26 lab=VDD}
C {madvlsi/vdd.sym} 990 -2150 0 0 {name=l34 lab=VDD}
C {madvlsi/nmos3.sym} 710 -1950 1 0 {name=M136
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 790 -1950 1 0 {name=M137
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 870 -1950 3 0 {name=M138
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 950 -1950 3 0 {name=M139
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1030 -1950 1 0 {name=M140
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1110 -1950 3 0 {name=M141
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 710 -1770 1 0 {name=M142
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 790 -1770 1 0 {name=M143
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 870 -1770 1 0 {name=M144
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 950 -1770 1 0 {name=M145
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1030 -1770 3 0 {name=M146
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1110 -1770 1 0 {name=M147
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1190 -1770 1 0 {name=M148
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1160 -2150 0 0 {name=l35 lab=VDD}
C {devices/lab_pin.sym} 320 -1800 0 0 {name=p60 sig_type=std_logic lab=RST}
C {madvlsi/gnd.sym} 750 -1640 0 0 {name=l36 lab=GND}
C {madvlsi/gnd.sym} 830 -1640 0 0 {name=l37 lab=GND}
C {madvlsi/gnd.sym} 990 -1760 0 0 {name=l38 lab=GND}
C {devices/lab_pin.sym} 1500 -2190 1 0 {name=p62 sig_type=std_logic lab=CompOut}
C {madvlsi/gnd.sym} 750 -1940 0 0 {name=l39 lab=GND}
C {madvlsi/gnd.sym} 1060 -1940 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} 320 -1880 0 0 {name=p63 sig_type=std_logic lab=AIn}
C {devices/lab_pin.sym} 1140 -2030 0 0 {name=p69 sig_type=std_logic lab=CompOutb}
C {madvlsi/pmos3.sym} 250 -1240 2 1 {name=M151
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 250 -1140 0 0 {name=M152
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 250 -1270 0 0 {name=l43 lab=VDD}
C {madvlsi/gnd.sym} 250 -1110 0 0 {name=l44 lab=GND}
C {devices/lab_pin.sym} -90 -1190 0 0 {name=p18 sig_type=std_logic lab=PRE}
C {devices/lab_pin.sym} 330 -1190 3 0 {name=p64 sig_type=std_logic lab=PREb}
C {madvlsi/pmos3.sym} 2600 -2020 1 1 {name=M155
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2600 -1880 1 0 {name=M156
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 2650 -2020 0 0 {name=l47 lab=VDD}
C {madvlsi/gnd.sym} 2650 -1880 0 0 {name=l48 lab=GND}
C {madvlsi/pmos3.sym} 1440 -1930 2 1 {name=M157
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1440 -1830 0 0 {name=M158
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1440 -1960 0 0 {name=l49 lab=VDD}
C {madvlsi/gnd.sym} 1440 -1800 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} 1460 -1880 2 0 {name=p65 sig_type=std_logic lab=ENADb}
C {devices/lab_pin.sym} 1390 -1880 0 0 {name=p70 sig_type=std_logic lab=ENAD}
C {madvlsi/gnd.sym} 2560 -250 0 0 {name=l19 lab=GND}
C {madvlsi/gnd.sym} 2540 -200 0 0 {name=l24 lab=GND}
C {madvlsi/gnd.sym} 2560 30 0 0 {name=l25 lab=GND}
C {madvlsi/gnd.sym} 2540 80 0 0 {name=l27 lab=GND}
C {madvlsi/gnd.sym} 2690 30 0 0 {name=l28 lab=GND}
C {madvlsi/gnd.sym} 2670 80 0 0 {name=l29 lab=GND}
C {madvlsi/gnd.sym} 2850 30 0 0 {name=l30 lab=GND}
C {madvlsi/gnd.sym} 2830 80 0 0 {name=l31 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2560 -280 0 0 {name=R5
L=0.385
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2560 0 0 0 {name=R1
L=0.42
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2690 0 0 0 {name=R2
L=0.42
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2850 0 0 0 {name=R3
L=0.42
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {madvlsi/pmos3.sym} 850 -1350 3 1 {name=M27
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 950 -1350 3 1 {name=M28
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 760 -1350 1 0 {name=M29
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 600 -1200 3 1 {name=M30
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 660 -1200 3 0 {name=M31
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 960 -1200 1 1 {name=M32
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 960 -1160 0 0 {name=p12 sig_type=std_logic lab=Db}
C {madvlsi/nmos3.sym} 960 -1040 3 1 {name=M33
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 880 -1200 3 1 {name=M34
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 880 -1040 1 1 {name=M35
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1160 -1350 1 0 {name=M36
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1060 -1350 1 0 {name=M37
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1250 -1350 3 1 {name=M38
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1420 -1200 1 0 {name=M39
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1040 -1200 3 0 {name=M40
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1040 -1160 0 1 {name=p14 sig_type=std_logic lab=D}
C {madvlsi/nmos3.sym} 1040 -1040 1 0 {name=M41
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1120 -1200 1 0 {name=M42
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1120 -1040 3 0 {name=M43
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 600 -1350 3 1 {name=M44
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 680 -1350 3 1 {name=M45
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1330 -1350 3 1 {name=M46
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1410 -1350 3 1 {name=M47
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 510 -1350 1 0 {name=M48
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 600 -1040 3 0 {name=M49
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 680 -1040 3 0 {name=M50
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1330 -1040 3 0 {name=M51
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1410 -1040 3 0 {name=M52
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1500 -1350 1 0 {name=M53
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1500 -1040 3 0 {name=M54
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 510 -1040 3 0 {name=M55
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 900 -1350 0 0 {name=l32 lab=VDD}
C {madvlsi/vdd.sym} 1110 -1350 0 0 {name=l41 lab=VDD}
C {madvlsi/gnd.sym} 850 -1040 0 0 {name=l33 lab=GND}
C {madvlsi/gnd.sym} 1150 -1040 0 0 {name=l53 lab=GND}
C {madvlsi/gnd.sym} 690 -1170 0 0 {name=l54 lab=GND}
C {madvlsi/pmos3.sym} 1720 -1350 1 0 {name=M149
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1720 -1030 3 0 {name=M150
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1720 -1000 3 0 {name=p35 sig_type=std_logic lab=SH}
C {devices/lab_pin.sym} 1720 -1380 1 0 {name=p58 sig_type=std_logic lab=SHb}
C {devices/lab_pin.sym} 1580 -1260 1 0 {name=p52 sig_type=std_logic lab=C-}
C {madvlsi/pmos3.sym} 1720 -1220 1 1 {name=M153
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1720 -1120 3 0 {name=M154
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1770 -1220 0 0 {name=l45 lab=VDD}
C {madvlsi/gnd.sym} 1770 -1120 0 0 {name=l46 lab=GND}
C {madvlsi/pmos3.sym} 2300 -1350 3 1 {name=M56
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2400 -1350 3 1 {name=M57
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2210 -1350 1 0 {name=M58
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2050 -1200 3 1 {name=M59
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2810 -1200 3 0 {name=M60
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2410 -1200 1 1 {name=M61
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 2410 -1160 0 0 {name=p2 sig_type=std_logic lab=Db}
C {madvlsi/nmos3.sym} 2410 -1040 3 1 {name=M62
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2330 -1200 3 1 {name=M63
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2330 -1040 1 1 {name=M64
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2610 -1350 1 0 {name=M65
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2510 -1350 1 0 {name=M66
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2700 -1350 3 1 {name=M67
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2870 -1200 1 0 {name=M68
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2490 -1200 3 0 {name=M69
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 2490 -1160 0 1 {name=p3 sig_type=std_logic lab=D}
C {madvlsi/nmos3.sym} 2490 -1040 1 0 {name=M70
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2570 -1200 1 0 {name=M71
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2570 -1040 3 0 {name=M72
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2050 -1350 3 1 {name=M73
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2130 -1350 3 1 {name=M74
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2780 -1350 3 1 {name=M75
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2860 -1350 3 1 {name=M76
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1960 -1350 1 0 {name=M77
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2050 -1040 3 0 {name=M78
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2130 -1040 3 0 {name=M79
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2780 -1040 3 0 {name=M80
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2860 -1040 3 0 {name=M81
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2950 -1350 1 0 {name=M82
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2950 -1040 3 0 {name=M83
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1960 -1040 3 0 {name=M84
L=0.15
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 2350 -1350 0 0 {name=l42 lab=VDD}
C {madvlsi/vdd.sym} 2560 -1350 0 0 {name=l51 lab=VDD}
C {madvlsi/gnd.sym} 2300 -1040 0 0 {name=l52 lab=GND}
C {madvlsi/gnd.sym} 2600 -1040 0 0 {name=l65 lab=GND}
C {madvlsi/gnd.sym} 2780 -1170 0 0 {name=l66 lab=GND}
C {devices/lab_pin.sym} 1900 -1260 1 0 {name=p4 sig_type=std_logic lab=C+}
C {madvlsi/gnd.sym} 550 -980 0 0 {name=l67 lab=GND}
C {madvlsi/gnd.sym} 1580 -1200 0 0 {name=l68 lab=GND}
C {madvlsi/gnd.sym} 1900 -1200 0 0 {name=l69 lab=GND}
C {madvlsi/gnd.sym} 2900 -980 0 0 {name=l70 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 550 -1010 0 0 {name=C3 model=cap_mim_m3_1 W=22.2 L=22.2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1580 -1230 0 0 {name=C4 model=cap_mim_m3_1 W=22.2 L=22.2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1900 -1230 0 0 {name=C7 model=cap_mim_m3_1 W=22.2 L=22.2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2900 -1010 0 0 {name=C8 model=cap_mim_m3_1 W=22.2 L=22.2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 750 -1670 0 0 {name=C9 model=cap_mim_m3_1 W=6.9 L=6.9 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 830 -1670 0 0 {name=C10 model=cap_mim_m3_1 W=6.9 L=6.9 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1790 -1730 0 0 {name=C1 model=cap_mim_m3_1 W=6.9 L=6.9 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2160 -1730 0 0 {name=C2 model=cap_mim_m3_1 W=6.9 L=6.9 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2720 -1730 0 0 {name=C5 model=cap_mim_m3_1 W=6.9 L=6.9 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3090 -1730 0 0 {name=C6 model=cap_mim_m3_1 W=6.9 L=6.9 MF=1 spiceprefix=X}
